# Repository mfkiwl/ETH1CDMM1ice40hx-stm32h7 (continued)

## KiCad design hardware/project/ETH1CDMM1/ETH1CDMM1.kicad_pcb (continued)

Schematic: Connector.sch

Parts:
C1201: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1201: C64AC; Socket_DIN41612-CaseC1-AC-Male-64Pin-2rows
K1201, K1202, K1203, K1204, K1205: HE3621A0510; HE360_x-5050462-8
U1201: ULN2003A; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+24V: J1201.A31 (31A), J1201.A32 (32A), J1201.C31 (31C), J1201.C32 (32C); also elsewhere on the board
/Connector/A: J1201.A2 (2A), J1201.C2 (2C), K1201.4
/Connector/B: J1201.A3 (3A), J1201.C3 (3C), K1202.4
/Connector/C: J1201.A4 (4A), J1201.C4 (4C), K1203.4
/Connector/CXN_REL1: U1201.6 (I6); also elsewhere on the board
/Connector/CXN_REL2: U1201.5 (I5); also elsewhere on the board
/Connector/CXN_REL3: U1201.4 (I4); also elsewhere on the board
/Connector/CXN_REL4: U1201.3 (I3); also elsewhere on the board
/Connector/CXN_REL5: U1201.2 (I2); also elsewhere on the board
/Connector/D: J1201.A5 (5A), J1201.C5 (5C)
/Connector/E: J1201.A6 (6A), J1201.C6 (6C), K1204.4
/Connector/EXT_TRIG: J1201.A16 (16A); also elsewhere on the board
/Connector/F: J1201.A7 (7A), J1201.C7 (7C), K1205.4
/Connector/G: J1201.A8 (8A), J1201.C8 (8C)
/Connector/H: K1201.1; also elsewhere on the board
/Connector/HS: K1205.1; also elsewhere on the board
/Connector/I: K1203.1; also elsewhere on the board
/Connector/K: J1201.A11 (11A), J1201.C11 (11C)
/Connector/LS: K1204.1; also elsewhere on the board
/Connector/M: J1201.A13 (13A), J1201.C13 (13C)
/Connector/RX+: J1201.A20 (20A); also elsewhere on the board
/Connector/RX-: J1201.A21 (21A); also elsewhere on the board
/Connector/TX+: J1201.C20 (20C); also elsewhere on the board
/Connector/TX-: J1201.C21 (21C); also elsewhere on the board
Earth: J1201.A18 (18A), J1201.A22 (22A), J1201.C18 (18C), J1201.C22 (22C); also elsewhere on the board
GNDPWR: J1201.A27 (27A), J1201.A28 (28A), J1201.C27 (27C), J1201.C28 (28C); also elsewhere on the board
GND_TRIG: J1201.C16 (16C); also elsewhere on the board
unnamed: J1201.A9 (9A), J1201.C9 (9C)
unnamed: J1201.A10 (10A), J1201.C10 (10C)
unnamed: J1201.A12 (12A), J1201.C12 (12C)
unnamed: K1201.3, U1201.11 (O6)
unnamed: K1202.3, U1201.12 (O5)
unnamed: K1203.3, U1201.13 (O4)
unnamed: K1204.3, U1201.14 (O3)
unnamed: K1205.3, U1201.15 (O2)

Schematic: SDRAM.sch

Parts:
C1301, C1302, C1303, C1304, C1305, C1306, C1307: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1301: IS42S16400J-xC; TSSOP-54

Connections:
+3.3VF: C1301.1, C1302.1, C1303.1, C1304.1, C1305.1, C1306.1, C1307.1, U1301.1 (VDD), U1301.3 (VDDQ), U1301.9 (VDDQ), U1301.14 (VDD), U1301.27 (VDD), U1301.43 (VDDQ), U1301.49 (VDDQ); also elsewhere on the board
/MCU/A0: U1301.23 (A0); also elsewhere on the board
/MCU/A1: U1301.24 (A1); also elsewhere on the board
/MCU/A2: U1301.25 (A2); also elsewhere on the board
/MCU/A3: U1301.26 (A3); also elsewhere on the board
/MCU/A4: U1301.29 (A4); also elsewhere on the board
/MCU/A5: U1301.30 (A5); also elsewhere on the board
/MCU/A6: U1301.31 (A6); also elsewhere on the board
/MCU/A7: U1301.32 (A7); also elsewhere on the board
/MCU/A8: U1301.33 (A8); also elsewhere on the board
/MCU/A9: U1301.34 (A9); also elsewhere on the board
/MCU/A10: U1301.22 (A10); also elsewhere on the board
/MCU/A11: U1301.35 (A11); also elsewhere on the board
/MCU/BA0: U1301.20 (BA0); also elsewhere on the board
/MCU/BA1: U1301.21 (BA1); also elsewhere on the board
/MCU/CKE: U1301.37 (CKE); also elsewhere on the board
/MCU/CLK: U1301.38 (CLK); also elsewhere on the board
/MCU/D0: U1301.2 (DQ0); also elsewhere on the board
/MCU/D1: U1301.4 (DQ1); also elsewhere on the board
/MCU/D2: U1301.5 (DQ2); also elsewhere on the board
/MCU/D3: U1301.7 (DQ3); also elsewhere on the board
/MCU/D4: U1301.8 (DQ4); also elsewhere on the board
/MCU/D5: U1301.10 (DQ5); also elsewhere on the board
/MCU/D6: U1301.11 (DQ6); also elsewhere on the board
/MCU/D7: U1301.13 (DQ7); also elsewhere on the board
/MCU/D8: U1301.42 (DQ8); also elsewhere on the board
/MCU/D9: U1301.44 (DQ9); also elsewhere on the board
/MCU/D10: U1301.45 (DQ10); also elsewhere on the board
/MCU/D11: U1301.47 (DQ11); also elsewhere on the board
/MCU/D12: U1301.48 (DQ12); also elsewhere on the board
/MCU/D13: U1301.50 (DQ13); also elsewhere on the board
/MCU/D14: U1301.51 (DQ14); also elsewhere on the board
/MCU/D15: U1301.53 (DQ15); also elsewhere on the board
/MCU/LDQM: U1301.15 (LDQM); also elsewhere on the board
/MCU/UDQM: U1301.39 (UDQM); also elsewhere on the board
/MCU/~CAS: U1301.17 (~CAS); also elsewhere on the board
/MCU/~CS: U1301.19 (~CS); also elsewhere on the board
/MCU/~RAS: U1301.18 (~RAS); also elsewhere on the board
/MCU/~WE: U1301.16 (~WE); also elsewhere on the board

Schematic: MCU.sch

Parts:
C1401, C1402, C1403, C1404, C1406, C1409, C1411, C1413, C1414, C1415, C1416, C1417, C1418, C1419, C1420, C1422: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C1405, C1407: 8p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C1408, C1410: 2u2; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C1412, C1421: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1401: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1402: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1403: BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1401: 742792031; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1401: Conn_02x01; PinHeader_1x02_P2.54mm_Vertical
J1402: 20021111-00010T4LF; PinHeader_2x05_P1.27mm_Vertical
R1401, R1409, R1410: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1402, R1403, R1407, R1408: 4k7; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1404, R1406: 680; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1405: 560; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1401: HDC1080; Texas_PWSON-N6
U1402: STM32H743ZI; TQFP-144_20x20mm_P0.5mm
U1403: 24LC08B-E/MS; MSOP-8_3x3mm_P0.65mm
Y1401: NX3225GD-8MHZ-STD-CRA-3; NX3225GD

Connections:
+3.3VF: C1401.1, C1402.1, C1403.1, C1404.1, C1406.1, C1409.1, C1411.1, C1412.1, C1413.1, C1414.1, C1415.1, C1416.1, C1417.1, C1418.1, C1419.1, C1420.1, D1401.2 (A), D1402.2 (A), D1403.2 (A), FB1401.2, J1402.1, R1401.2, R1402.1, R1403.1, R1407.1, R1408.1, R1410.1, U1401.5 (VCC), U1402.6 (VBAT), U1402.17 (VDD), U1402.30 (VDD), U1402.39 (VDD), U1402.52 (VDD), U1402.62 (VDD), U1402.72 (VDD), U1402.84 (VDD), U1402.95 (VDDUSB), U1402.108 (VDD), U1402.121 (VDD), U1402.131 (VDD), U1402.143 (PDR_ON), U1402.144 (VDD), U1403.8 (VCC); also elsewhere on the board
/Connector/CXN_REL1: U1402.69 (PB10,TIM2_CH3,I2C2_SCL,SPI2_SCK,I2S2_CK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); also elsewhere on the board
/Connector/CXN_REL2: U1402.70 (PB11,TIM2_CH4,I2C2_SDA,DFSDM1_CKIN7,USA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); also elsewhere on the board
/Connector/CXN_REL3: U1402.73 (PB12,TIM1_BKIN,I2C2_SMBA,SPI2_NSS,I2S2_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); also elsewhere on the board
/Connector/CXN_REL4: U1402.74 (PB13,TIM1_CH1N,SPI2_SCK,I2S2_CK,DFSDM1_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); also elsewhere on the board
/Connector/CXN_REL5: U1402.75 (PB14,TIM1_CH2N,TIM8_CH2N,USART1_TX,SPI2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); also elsewhere on the board
/DC Amplifier/AMPL_SEL: U1402.101 (PA9,TIM1_CH2,I2C3_SMBA,SPI2_SCK,I2S2_CK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); also elsewhere on the board
/DC Amplifier/DC_AMP1_MUX_A0: U1402.111 (PC10,DFSDM1_CKIN5,SPI3_SCK,I2S3_CK,USAR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); also elsewhere on the board
/DC Amplifier/DC_AMP1_MUX_A1: U1402.112 (PC11,DFSDM1_DATIN5,SPI3_MISO,USART3_RX,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); also elsewhere on the board
/DC Amplifier/DC_AMP1_MUX_EN: U1402.113 (PC12,TRACED3,SPI3_MOSI,I2S3_SD,USART3_C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); also elsewhere on the board
/DC Amplifier/DC_AMP2_MUX_A0: U1402.102 (PA10,TIM1_CH3,USART1_RX,LCD_B4,OTG_FS_I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); also elsewhere on the board
/DC Amplifier/DC_AMP2_MUX_A1: U1402.103 (PA11,TIM1_CH4,SPI2_NSS,I2S2_WS,UART4_RX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); also elsewhere on the board
/DC Amplifier/DC_AMP2_MUX_EN: U1402.104 (PA12,TIM1_ETR,SPI2_SCK,I2S2_CK,UART4_TX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); also elsewhere on the board
/DC Amplifier/DC_AMP_10MEG: U1402.28 (PC2,DFSDM1_CKIN1,SPI2_MISO,DFSDM1_CKOUT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); also elsewhere on the board
/Ethernet/NRST: C1422.1, J1402.10, R1410.2, U1402.25 (NRST); also elsewhere on the board
/Ethernet/REF_CLK: U1402.35 (PA1,TIM2_CH2,TIM5_CH2,UART2_RTS,UART4_R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); also elsewhere on the board
/Ethernet/RMII_CRS_DV: U1402.43 (PA7,TIM1_CH1N,TIM3_CH2,TIM8_CH1N,SPI1_M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); also elsewhere on the board
/Ethernet/RMII_MDC: U1402.27 (PC1,TRACED0,_DFSDM1_DATIN0,SPI2_MOSI,I2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); also elsewhere on the board
/Ethernet/RMII_MDIO: U1402.36 (PA2,TIM2_CH3,TIM5_CH3,TIM9_CH1,USART2_T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); also elsewhere on the board
/Ethernet/RMII_RXD0: U1402.44 (PC4,DFSDM1_CKIN2,I2S1_MCK,SPDIF_RX2,ETH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); also elsewhere on the board
/Ethernet/RMII_RXD1: U1402.45 (PC5,DFSDM1_DATIN2,SPDIF_RX3,ETH_MII_RXD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); also elsewhere on the board
/Ethernet/RMII_TXD0: U1402.128 (PG13,TRACED0,LPTIM1_OUT,SPI6_SCK,USART6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); also elsewhere on the board
/Ethernet/RMII_TXD1: U1402.129 (PG14,TRACED1,LPTIM1_ETR,SPI6_MOSI,USART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); also elsewhere on the board
/Ethernet/RMII_TXEN: U1402.126 (PG11,SPI1_SCK,I2S1_CK,SPDIF_RX0,SDMMC2_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); also elsewhere on the board
/FPGA/FPGA_IO1: U1402.117 (PD3,DFSDM1_CKOUT,SPI2_SCK,I2S2_CK,DFSDM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); also elsewhere on the board
/FPGA/FPGA_IO2: U1402.118 (PD4,DFSDM1_CKIN0,USART2_RTS,FMC_NOE,EVE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); also elsewhere on the board
/FPGA/FPGA_SPI1_MISO: U1402.124 (PG9,SPI1_MISO,SPDIF_RX3,USART6_RX,QUADS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); also elsewhere on the board
/FPGA/FPGA_SPI1_MOSI: U1402.123 (PD7,DFSDM1_DATIN4,SPI1_MOSI,I2S1_SD,DFS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); also elsewhere on the board
/FPGA/FPGA_SPI1_NSS: U1402.125 (PG10,SPI1_NSS,I2S1_WS,LCD_G3,SAI2_SD_B,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); also elsewhere on the board
/FPGA/FPGA_SPI1_SCK: U1402.41 (PA5,TIM2_CH1,TIM2_ETR,TIM8_CH1N,SPI1_SC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); also elsewhere on the board
/FPGA/FPGA_UART2_RX_TTL: U1402.122 (PD6,DFSDM1_CKIN4,SPI3_MOSI,I2S3_SD,SAI1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); also elsewhere on the board
/FPGA/FPGA_UART2_TX_TTL: U1402.119 (PD5,USART2_TX,FMC_NWE,EVENTOUT); also elsewhere on the board
/Function Selection/SLE_SCLK: U1402.1 (PE2,TRACECLK,SPI4_SCK,SAI1_MCLK_A,QUADS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); also elsewhere on the board
/Function Selection/SLE_SI: U1402.5 (PE6,TRACED3,TIM1_BKIN2,TIM9_CH2,SPI4_MO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); also elsewhere on the board
/Function Selection/SLE_SO: U1402.4 (PE5,TRACED2,TIM9_CH1,SPI4_MISO,SAI1_SCK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); also elsewhere on the board
/Function Selection/SLE_~CS: U1402.3 (PE4,TRACED1,SPI4_NSS,SAI1_FS_A,DFSDM1_D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); also elsewhere on the board
/Function Selection/SLE_~RST: U1402.2 (PE3,TRACED0,SAI1_SD_B,FMC_A19,EVENTOUT); also elsewhere on the board
/MCU/A0: U1402.10 (PF0,I2C2_SDA,FMC_A0,EVENTOUT); also elsewhere on the board
/MCU/A1: U1402.11 (PF1,I2C2_SCL,FMC_A1,EVENTOUT); also elsewhere on the board
/MCU/A2: U1402.12 (PF2,I2C2_SMBA,FMC_A2,EVENTOUT); also elsewhere on the board
/MCU/A3: U1402.13 (PF3,FMC_A3,EVENTOUT,ADC3_IN9); also elsewhere on the board
/MCU/A4: U1402.14 (PF4,FMC_A4,EVENTOUT,ADC3_IN14); also elsewhere on the board
/MCU/A5: U1402.15 (PF5,FMC_A5,EVENTOUT,ADC3_IN15); also elsewhere on the board
/MCU/A6: U1402.50 (PF12,FMC_A6,EVENTOUT); also elsewhere on the board
/MCU/A7: U1402.53 (PF13,I2C4_SMBA,DFSDM1_DATIN6,FMC_A7,EVE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); also elsewhere on the board
/MCU/A8: U1402.54 (PF14,I2C4_SCL,DFSDM1_CKIN6,FMC_A8,EVENT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); also elsewhere on the board
/MCU/A9: U1402.55 (PF15,I2C4_SDA,FMC_A9,EVENTOUT); also elsewhere on the board
/MCU/A10: U1402.56 (PG0,FMC_A10,EVENTOUT); also elsewhere on the board
/MCU/A11: U1402.57 (PG1,FMC_A11,EVENTOUT); also elsewhere on the board
/MCU/BA0: U1402.89 (PG4,FMC_A14,FMC_BA0,EVENTOUT); also elsewhere on the board
/MCU/BA1: U1402.90 (PG5,FMC_A15,FMC_BA1,EVENTOUT); also elsewhere on the board
/MCU/CKE: U1402.135 (PB5,UART5_RX,TIM3_CH2,I2C1_SMBA,SPI1_MO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); also elsewhere on the board
/MCU/CLK: U1402.93 (PG8,SPI6_NSS,SPDIF_RX2,USART6_RTS,ETH_P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); also elsewhere on the board
/MCU/D0: U1402.85 (PD14,TIM4_CH3,UART8_CTS,FMC_D0,EVENTOUT); also elsewhere on the board
/MCU/D1: U1402.86 (PD15,TIM4_CH4,UART8_RTS,FMC_D1,EVENTOUT); also elsewhere on the board
/MCU/D2: U1402.114 (PD0,DFSDM1_CKIN6,DFSDM1_DATIN7,UART4_RX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); also elsewhere on the board
/MCU/D3: U1402.115 (PD1,DFSDM1_DATIN6,DFSDM1_CKIN7,UART4_TX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); also elsewhere on the board
/MCU/D4: U1402.58 (PE7,TIM1_ETR,DFSDM1_DATIN2,UART7_RX,QUA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); also elsewhere on the board
/MCU/D5: U1402.59 (PE8,TIM1_CH1N,DFSDM1_CKIN2,UART7_TX,QUA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); also elsewhere on the board
/MCU/D6: U1402.60 (PE9,TIM1_CH1,DFSDM1_CKOUT,UART7_RTS,QUA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); also elsewhere on the board
/MCU/D7: U1402.63 (PE10,TIM1_CH2N,DFSDM1_DATIN4,UART7_CTS,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); also elsewhere on the board
/MCU/D8: U1402.64 (PE11,TIM1_CH2,SPI4_NSS,DFSDM1_CKIN4,SAI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); also elsewhere on the board
/MCU/D9: U1402.65 (PE12,TIM1_CH3N,SPI4_SCK,DFSDM1_DATIN5,S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); also elsewhere on the board
/MCU/D10: U1402.66 (PE13,TIM1_CH3,SPI4_MISO,DFSDM1_CKIN5,SA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); also elsewhere on the board
/MCU/D11: U1402.67 (PE14,TIM1_CH4,SPI4_MOSI,SAI2_MCLK_B,FMC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); also elsewhere on the board
/MCU/D12: U1402.68 (PE15,TIM1_BKIN,FMC_D12,LCD_R7,EVENTOUT); also elsewhere on the board
/MCU/D13: U1402.77 (PD8,DFSDM1_CKIN3,USART3_TX,SPDIF_RX1,FM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); also elsewhere on the board
/MCU/D14: U1402.78 (PD9,DFSDM1_DATIN3,USART3_RX,FMC_D14,EVE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); also elsewhere on the board
/MCU/D15: U1402.79 (PD10,DFSDM1_CKOUT,USART3_CK,FMC_D15,LCD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); also elsewhere on the board
/MCU/EEPROM_SCL: R1408.2, U1402.81 (PD12,TIM4_CH1,LPTIM1_IN1,I2C4_SCL,USART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), U1403.6 (SCL)
/MCU/EEPROM_SDA: R1407.2, U1402.82 (PD13,TIM4_CH2,LPTIM1_OUT,I2C4_SDA,QUADS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), U1403.5 (SDA)
/MCU/EEPROM_WP: U1402.80 (PD11,I2C4_SMBA,USART3_CTS,QUADSPI_BK1_I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), U1403.7 (WP)
/MCU/LDQM: U1402.141 (PE0,TIM4_ETR,LPTIM1_ETR,UART8_RX,SAI2_M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); also elsewhere on the board
/MCU/MCU_DEFAULT: J1401.1, R1401.1, U1402.140 (PB9,I2C4_SDA,TIM4_CH4,TIM11_CH1,I2C1_SD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)
/MCU/MCU_VDDA: C1421.1, FB1401.1, U1402.32 (VREF+), U1402.33 (VDDA)
/MCU/OCS_DIN: U1402.21 (PF9,SPI5_MOSI,SAI1_FS_B,UART7_CTS,TIM14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); also elsewhere on the board
/MCU/OCS_SCLK: U1402.19 (PF7,TIM11_CH1,SPI5_SCK,SAI1_MCLK_B,UART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); also elsewhere on the board
/MCU/OCS_SDO: U1402.20 (PF8,SPI5_MISO,SAI1_SCK_B,UART7_RTS,TIM1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); also elsewhere on the board
/MCU/OCS_~SYNC: U1402.18 (PF6,TIM10_CH1,SPI5_NSS,SAI1_SD_B,UART7_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); also elsewhere on the board
/MCU/OSC_HV_PROT: U1402.22 (PF10,QUADSPI_CLK,DCMI_D11,LCD_DE,EVENTO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); also elsewhere on the board
/MCU/SENS_SCL: R1402.2, U1401.6 (SCL), U1402.100 (PA8,MCO1,TIM1_CH1,TIM8_BKIN2,I2C3_SCL,U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)
/MCU/SENS_SDA: R1403.2, U1401.1 (SDA), U1402.99 (PC9,MCO2,TIM3_CH4,TIM8_CH4,I2C3_SDA,I2S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)
/MCU/TCK_SWCLK: J1402.4, U1402.109 (PA14,JTCK-SWCLK,EVENTOUT)
/MCU/TMS_SWDIO: J1402.2, U1402.105 (PA13,JTMS-SWDIO,EVENTOUT)
/MCU/TRIG_EN: U1402.48 (PB2,SAI1_SD_A,SPI3_MOSI,I2S3_SD,QUADSPI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); also elsewhere on the board
/MCU/TRIG_IN: U1402.46 (PB0,TIM1_CH2N,TIM3_CH3,TIM8_CH2N,DFSDM1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); also elsewhere on the board
/MCU/TRIG_OUT: U1402.47 (PB1,TIM1_CH3N,TIM3_CH4,TIM8_CH3N,DFSDM1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); also elsewhere on the board
/MCU/UDQM: U1402.142 (PE1,LPTIM1_IN2,UART8_TX,FMC_NBL1,DCMI_D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); also elsewhere on the board
/MCU/~CAS: U1402.132 (PG15,USART6_CTS,FMC_SDNCAS,DCMI_D13,EVE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); also elsewhere on the board
/MCU/~CS: U1402.136 (PB6,UART5_TX,TIM4_CH1,HDMI_CEC,I2C1_SCL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); also elsewhere on the board
/MCU/~RAS: U1402.49 (PF11,SPI5_MOSI,SAI2_SD_B,FMC_SDNRAS,_DC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); also elsewhere on the board
/MCU/~WE: U1402.26 (PC0,DFSDM1_CKIN0,DFSDM1_DATIN4,SAI2_FS_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); also elsewhere on the board
unnamed: C1405.1, U1402.23 (PH0,EVENTOUT,OSC_IN), Y1401.1
unnamed: C1407.1, U1402.24 (PH1,EVENTOUT,OSC_OUT), Y1401.2
unnamed: C1408.1, U1402.71 (VCAP_1)
unnamed: C1410.1, U1402.106 (VCAP_2)
unnamed: D1401.1 (K), R1404.2
unnamed: D1402.1 (K), R1405.2
unnamed: D1403.1 (K), R1406.2
unnamed: R1404.1, U1402.7 (PC13,EVENTOUT,RTC_TAMP2,RTC_TS,WKUP5)
unnamed: R1405.1, U1402.8 (PC14,EVENTOUT,OSC32_IN)
unnamed: R1406.1, U1402.9 (PC15,EVENTOUT,OSC32_OUT)
unnamed: R1409.1, U1402.138 (BOOT0)

Notes on the sheet:
PROGRAMMING CONNECTOR DESIGNED FOR JLINK

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
Board: 6 copper layers, 160.0 x 100.0 mm, 482 parts (0 on the bottom side), 409 nets.

Other parts of the board:
C715, C716: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C717: 2n2; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C718: 220n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R934, R935: OPT; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Their connections:
unnamed 349: R934.1; also elsewhere on the board
unnamed 350: R934.2; also elsewhere on the board
unnamed 351: R935.1; also elsewhere on the board
unnamed 352: R935.2; also elsewhere on the board

## Code that names these connections

File software/MCU/ETH1CDMM1_MCU.ioc (part):

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Mcu.Name=STM32F765Z(G-I)Tx
Mcu.Package=LQFP144
Mcu.UserName=STM32F765ZGTx
PA0/WKUP.GPIOParameters=GPIO_Label
PA0/WKUP.GPIO_Label=MCU_DEFAULT
PA0/WKUP.Signal=GPIO_Input
PA1.Mode=RMII
PA1.Signal=ETH_REF_CLK
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=DC_AMP2_MUX_A0
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=DC_AMP2_MUX_A1
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=DC_AMP2_MUX_EN
PA12.Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=DC_AMP_10MEG
PA15.Signal=GPIO_Output
PA2.Mode=RMII
PA2.Signal=ETH_MDIO
PA4.Mode=Synchronous
PA4.Signal=USART2_CK
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=FPGA_SPI1_SCK
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA7.Mode=RMII
PA7.Signal=ETH_CRS_DV
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=TSENS_SCL
PA8.Mode=I2C
PA8.Signal=I2C3_SCL
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=AMPL_SEL
PA9.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PB12.GPIO_Label=TRIG_IN
PB12.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING
PB12.Signal=GPXTI12
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=TRIG_OUT
PB13.Signal=GPIO_Output
PB14.GPIOParameters=PinState,GPIO_Label
PB14.GPIO_Label=TRIG_EN
PB14.PinState=GPIO_PIN_SET
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=CXN_REL1
PB15.Signal=GPIO_Output
PB5.Mode=SdramChipSelect2_1
PB5.Signal=FMC_SDCKE1
PB6.Mode=SdramChipSelect2_1
PB6.Signal=FMC_SDNE1
PC0.Signal=FMC_SDNWE
PC1.Mode=RMII
PC1.Signal=ETH_MDC
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=OSC_HV_PROT
PC10.Signal=GPIO_Output
PC13.GPIOParameters=PinState,GPIO_Label
PC13.GPIO_Label=LED_RED
PC13.PinState=GPIO_PIN_SET
PC13.Signal=GPIO_Output
PC14/OSC32_IN.GPIOParameters=PinState,GPIO_Label
PC14/OSC32_IN.GPIO_Label=LED_GREEN
PC14/OSC32_IN.PinState=GPIO_PIN_SET
PC14/OSC32_IN.Signal=GPIO_Output
PC15/OSC32_OUT.GPIOParameters=PinState,GPIO_Label
PC15/OSC32_OUT.GPIO_Label=LED_BLUE
PC15/OSC32_OUT.PinState=GPIO_PIN_SET
PC15/OSC32_OUT.Signal=GPIO_Output
PC4.Mode=RMII
PC4.Signal=ETH_RXD0
PC5.Mode=RMII
PC5.Signal=ETH_RXD1
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=DC_AMP1_MUX_EN
PC6.Signal=GPIO_Output
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=DC_AMP1_MUX_A1
PC7.Signal=GPIO_Output
PC8.GPIOParameters=GPIO_Label
PC8.GPIO_Label=DC_AMP1_MUX_A0
PC8.Signal=GPIO_Output
PC9.GPIOParameters=GPIO_Label
PC9.GPIO_Label=TSENS_SDA
PC9.Mode=I2C
PC9.Signal=I2C3_SDA
PD0.Signal=FMC_D2_DA2
PD1.Signal=FMC_D3_DA3
PD10.Signal=FMC_D15_DA15
PD11.GPIOParameters=PinState,GPIO_Label
PD11.GPIO_Label=EEPROM_WP
PD11.PinState=GPIO_PIN_SET
PD11.Signal=GPIO_Output
PD12.GPIOParameters=GPIO_Label
PD12.GPIO_Label=EEPROM_SCL
PD12.Mode=I2C
PD12.Signal=I2C4_SCL
PD13.GPIOParameters=GPIO_Label
PD13.GPIO_Label=EEPROM_SDA
PD13.Mode=I2C
PD13.Signal=I2C4_SDA
PD14.Signal=FMC_D0_DA0
PD15.Signal=FMC_D1_DA1
PD3.GPIOParameters=GPIO_Label
PD3.GPIO_Label=FPGA_IO1
PD3.Signal=GPIO_Output
PD4.GPIOParameters=GPIO_Label
PD4.GPIO_Label=FPGA_IO2
PD4.Signal=GPIO_Input
PD5.GPIOParameters=GPIO_Label
PD5.GPIO_Label=FPGA_UART2_TX_TTL
PD5.Mode=Synchronous
PD5.Signal=USART2_TX
PD6.GPIOParameters=GPIO_Label
PD6.GPIO_Label=FPGA_UART2_RX_TTL
PD6.Mode=Synchronous
PD6.Signal=USART2_RX
PD7.GPIOParameters=GPIO_Label
PD7.GPIO_Label=FPGA_SPI1_MOSI
PD7.Mode=Full_Duplex_Master
PD7.Signal=SPI1_MOSI
PD8.Signal=FMC_D13_DA13
PD9.Signal=FMC_D14_DA14
PE0.Signal=FMC_NBL0
PE1.Signal=FMC_NBL1
PE10.Signal=FMC_D7_DA7
PE11.Signal=FMC_D8_DA8
PE12.Signal=FMC_D9_DA9
PE13.Signal=FMC_D10_DA10
PE14.Signal=FMC_D11_DA11
PE15.Signal=FMC_D12_DA12
PE2.GPIOParameters=GPIO_Label
PE2.GPIO_Label=SLE_SCLK
PE2.Mode=Full_Duplex_Master
PE2.Signal=SPI4_SCK
PE3.GPIOParameters=PinState,GPIO_Label
PE3.GPIO_Label=SLE_nRST
PE3.PinState=GPIO_PIN_SET
PE3.Signal=GPIO_Output
PE4.GPIOParameters=PinState,GPIO_Label
PE4.GPIO_Label=SLE_nCS
PE4.PinState=GPIO_PIN_SET
PE4.Signal=GPIO_Output
PE5.GPIOParameters=GPIO_Label
PE5.GPIO_Label=SLE_SO
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE6.GPIOParameters=GPIO_Label
PE6.GPIO_Label=SLE_SI
PE6.Mode=Full_Duplex_Master
PE6.Signal=SPI4_MOSI
PE7.Signal=FMC_D4_DA4
PE8.Signal=FMC_D5_DA5
PE9.Signal=FMC_D6_DA6
PF0.Signal=FMC_A0
PF1.Signal=FMC_A1
PF11.Signal=FMC_SDNRAS
PF12.Signal=FMC_A6
PF13.Signal=FMC_A7
PF14.Signal=FMC_A8
PF15.Signal=FMC_A9
PF2.Signal=FMC_A2
PF3.Signal=FMC_A3
PF4.Signal=FMC_A4
PF5.Signal=FMC_A5
PF6.GPIOParameters=PinState,GPIO_Label
PF6.GPIO_Label=OCS_nSYNC
PF6.PinState=GPIO_PIN_SET
PF6.Signal=GPIO_Output
PF7.GPIOParameters=GPIO_Label
PF7.GPIO_Label=OCS_SPI5_SCK
PF7.Mode=Full_Duplex_Master
PF7.Signal=SPI5_SCK
PF8.GPIOParameters=GPIO_Label
PF8.GPIO_Label=OCS_SPI5_MISO
PF8.Mode=Full_Duplex_Master
PF8.Signal=SPI5_MISO
PF9.GPIOParameters=GPIO_Label
PF9.GPIO_Label=OCS_SPI5_MOSI
PF9.Mode=Full_Duplex_Master
PF9.Signal=SPI5_MOSI
PG0.Signal=FMC_A10
PG1.Signal=FMC_A11
PG10.GPIOParameters=PinState,GPIO_Label
PG10.GPIO_Label=FPGA_SPI1_NSS
PG10.PinState=GPIO_PIN_SET
PG10.Signal=GPIO_Output
PG11.Mode=RMII
PG11.Signal=ETH_TX_EN
PG13.Mode=RMII
PG13.Signal=ETH_TXD0
PG14.Mode=RMII
PG14.Signal=ETH_TXD1
PG15.Signal=FMC_SDNCAS
PG2.GPIOParameters=GPIO_Label
PG2.GPIO_Label=CXN_REL2
PG2.Signal=GPIO_Output
PG3.GPIOParameters=GPIO_Label
PG3.GPIO_Label=CXN_REL3
PG3.Signal=GPIO_Output
PG4.Signal=FMC_A14_BA0
PG5.Signal=FMC_A15_BA1
PG6.GPIOParameters=GPIO_Label
PG6.GPIO_Label=CXN_REL4
PG6.Signal=GPIO_Output
PG7.GPIOParameters=GPIO_Label
PG7.GPIO_Label=CXN_REL5
PG7.Signal=GPIO_Output
PG8.Signal=FMC_SDCLK
PG9.GPIOParameters=GPIO_Label
PG9.GPIO_Label=FPGA_SPI1_MISO
PG9.Mode=Full_Duplex_Master
PG9.Signal=SPI1_MISO
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=200000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File software/MCU/MCU.ioc (part):

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Mcu.Name=STM32H743ZITx
Mcu.Package=LQFP144
Mcu.UserName=STM32H743ZITx
PA1.Mode=RMII
PA1.Signal=ETH_REF_CLK
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=DC_AMP2_MUX_A0
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=DC_AMP2_MUX_A1
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=DC_AMP2_MUX_EN
PA12.Signal=GPIO_Output
PA13\ (JTMS/SWDIO).Mode=Serial_Wire
PA13\ (JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14\ (JTCK/SWCLK).Mode=Serial_Wire
PA14\ (JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA2.Mode=RMII
PA2.Signal=ETH_MDIO
PA4.Mode=Synchronous
PA4.Signal=USART2_CK
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA7.Mode=RMII
PA7.Signal=ETH_CRS_DV
PA8.Mode=I2C
PA8.Signal=I2C3_SCL
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=AMPL_SELm
PA9.Signal=GPIO_Output
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=TRIG_IN
PB0.Signal=GPIO_Input
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=TRIG_OUT
PB1.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=CXN_REL1
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=CXN_REL2
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=CXN_REL3
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=CXN_REL4
PB13.Signal=GPIO_Output
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=CXN_REL5
PB14.Signal=GPIO_Output
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=TRIG_EN
PB2.Signal=GPIO_Output
PB5.Mode=SdramChipSelect2_1
PB5.Signal=FMC_SDCKE1
PB6.Mode=SdramChipSelect2_1
PB6.Signal=FMC_SDNE1
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=MCU_DEFAULT
PB9.Signal=GPIO_Input
PC0.Signal=FMC_SDNWE
PC1.Mode=RMII
PC1.Signal=ETH_MDC
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=DC_AMP1_MUX_A0
PC10.Signal=GPIO_Output
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=DC_AMP1_MUX_A1
PC11.Signal=GPIO_Output
PC12.GPIOParameters=GPIO_Label
PC12.GPIO_Label=DC_AMP1_MUX_EN
PC12.Signal=GPIO_Output
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=LED_RED
PC13.Signal=GPIO_Output
PC14-OSC32_IN\ (OSC32_IN).GPIOParameters=GPIO_Label
PC14-OSC32_IN\ (OSC32_IN).GPIO_Label=LED_GREEN
PC14-OSC32_IN\ (OSC32_IN).Signal=GPIO_Output
PC15-OSC32_OUT\ (OSC32_OUT).GPIOParameters=GPIO_Label
PC15-OSC32_OUT\ (OSC32_OUT).GPIO_Label=LED_BLUE
PC15-OSC32_OUT\ (OSC32_OUT).Signal=GPIO_Output
PC2_C.GPIOParameters=GPIO_Label
PC2_C.GPIO_Label=DC_AMP_10MEG
PC2_C.Signal=GPIO_Output
PC4.Mode=RMII
PC4.Signal=ETH_RXD0
PC5.Mode=RMII
PC5.Signal=ETH_RXD1
PC9.Mode=I2C
PC9.Signal=I2C3_SDA
PD0.Signal=FMC_D2_DA2
PD1.Signal=FMC_D3_DA3
PD10.Signal=FMC_D15_DA15
PD11.GPIOParameters=GPIO_Label
PD11.GPIO_Label=EEPROM_WP
PD11.Signal=GPIO_Output
PD12.Mode=I2C
PD12.Signal=I2C4_SCL
PD13.Mode=I2C
PD13.Signal=I2C4_SDA
PD14.Signal=FMC_D0_DA0
PD15.Signal=FMC_D1_DA1
PD3.GPIOParameters=GPIO_Label
PD3.GPIO_Label=FPGA_IO1
PD3.Signal=GPIO_Input
PD4.GPIOParameters=GPIO_Label
PD4.GPIO_Label=FPGA_IO2
PD4.Signal=GPIO_Output
PD5.Mode=Synchronous
PD5.Signal=USART2_TX
PD6.Mode=Synchronous
PD6.Signal=USART2_RX
PD7.Mode=Full_Duplex_Master
PD7.Signal=SPI1_MOSI
PD8.Signal=FMC_D13_DA13
PD9.Signal=FMC_D14_DA14
PE0.Signal=FMC_NBL0
PE1.Signal=FMC_NBL1
PE10.Signal=FMC_D7_DA7
PE11.Signal=FMC_D8_DA8
PE12.Signal=FMC_D9_DA9
PE13.Signal=FMC_D10_DA10
PE14.Signal=FMC_D11_DA11
PE15.Signal=FMC_D12_DA12
PE2.Mode=Full_Duplex_Master
PE2.Signal=SPI4_SCK
PE3.GPIOParameters=GPIO_Label
PE3.GPIO_Label=SLE_nRST
PE3.Signal=GPIO_Output
PE4.Mode=NSS_Signal_Hard_Output
PE4.Signal=SPI4_NSS
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE6.Mode=Full_Duplex_Master
PE6.Signal=SPI4_MOSI
PE7.Signal=FMC_D4_DA4
PE8.Signal=FMC_D5_DA5
PE9.Signal=FMC_D6_DA6
PF0.Signal=FMC_A0
PF1.Signal=FMC_A1
PF11.Signal=FMC_SDNRAS
PF12.Signal=FMC_A6
PF13.Signal=FMC_A7
PF14.Signal=FMC_A8
PF15.Signal=FMC_A9
PF2.Signal=FMC_A2
PF3.Signal=FMC_A3
PF4.Signal=FMC_A4
PF5.Signal=FMC_A5
PF6.Mode=NSS_Signal_Hard_Output
PF6.Signal=SPI5_NSS
PF7.Mode=Full_Duplex_Master
PF7.Signal=SPI5_SCK
PF8.Mode=Full_Duplex_Master
PF8.Signal=SPI5_MISO
PF9.Mode=Full_Duplex_Master
PF9.Signal=SPI5_MOSI
PG0.Signal=FMC_A10
PG1.Signal=FMC_A11
PG10.Mode=NSS_Signal_Hard_Output
PG10.Signal=SPI1_NSS
PG11.Mode=RMII
PG11.Signal=ETH_TX_EN
PG13.Mode=RMII
PG13.Signal=ETH_TXD0
PG14.Mode=RMII
PG14.Signal=ETH_TXD1
PG15.Signal=FMC_SDNCAS
PG4.Signal=FMC_A14_BA0
PG5.Signal=FMC_A15_BA1
PG8.Signal=FMC_SDCLK
PG9.Mode=Full_Duplex_Master
PG9.Signal=SPI1_MISO
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=480000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File software/MCU/Core/Inc/bsp_switch.h:

/*
 * bsp_switch.h
 *
 *  Created on: Sep 10, 2020
 *      Author: grzegorz
 */

#ifndef INC_BSP_SWITCH_H_
#define INC_BSP_SWITCH_H_

#include "bsp.h"
#include "main.h"

#define U1011 1
#define U1006 2

#define CXN_REL1 0x02
#define CXN_REL2 0x04
#define CXN_REL3 0x08
#define CXN_REL4 0x10
#define CXN_REL5 0x20

#define DCV_L_CTR	0x0001U
#define VZERO_CTR	0x0002U
#define R4W_LO_CTR	0x0004U
#define MZ_CTR		0x0008U
#define DCV_H_CTR	0x0010U
#define MC_CTR		0x0020U
#define AMPS_CTR	0x0040U
#define R4W_HI_CTR	0x0080U
#define DCV_A_CTR	0x0100U
#define L_RLY		0x2000U
#define XH_RLY		0x4000U
#define XO_A_RLY 	0x8000U

#define GAIN_CIRCUIT1 0
#define GAIN_CIRCUIT2 1

#define LOAD_10MEG_OFF 0
#define LOAD_10MEG_ON 1

#define TMUX6104_MUX1 1
#define TMUX6104_MUX2 2

#define GAIN_1		1
#define GAIN_10		10
#define GAIN_100	100

#define SWITCH_OFF		0
#define SWITCH_ON		1

#define HE3621_REL_COUNT 5

typedef union
{
	uint16_t word16;
	uint8_t bytes[2];
}switch_data_t;

void SWITCH_ULN2003A_Control(uint8_t relay, uint8_t state);
void SWITCH_ULN2003A_ClearAll();

BSP_StatusTypeDef SWITCH_MCZ33996_Control(uint16_t relay, uint8_t state);
BSP_StatusTypeDef SWITCH_MCZ33996_ClearAll();

void SWITCH_DG419_Control(uint8_t gain_circuit);
void SWITCH_9012_Control(uint8_t select_10meg_load);

void SWITCH_TMUX6104_Control(uint8_t select_mux, uint8_t select_gain);
void SWITCH_TMUX6104_ClearAll();

#endif /* INC_BSP_SWITCH_H_ */

## Commit log

2020-02-03 Schematic design
2020-02-04 Schematic design, added new 3d models.
2020-02-05 DC_Amplifier.sch design.
2020-02-09 Schematic and software design.
2020-02-09 No unconnected nets in schematic
2020-02-12 Footprint assigment
2020-02-13 Footprint assignment done.
2020-02-14 FPGA was wrong, fixed. PCB design.
2020-02-18 Bug fix in schematic, PCB layout.
2020-02-20 PCB layout
2020-03-03 Schematic and PCB changes
2020-03-05 Added EMC shield.
2020-03-05 Redesigned the PCB for the EMC shield. Moved power and ground planes.
2020-03-06 PCB layout.
2020-03-06 PCB layout done.
2020-03-08 PCB and BOM list done.
2020-03-10 Fix small bugs in PCB.
2020-03-10 Gerber files created
2020-03-10 PCB done
2020-03-12 Changes in FPGA part.
2020-03-12 PCB solder mask changes
2020-03-12 Changed TO-71 footprint
2020-03-16 PCB changes
2020-03-17 Gerber send.
2020-07-19 FreeRTOS works, LwIP works, SDRAM works.
2020-08-12 FPGA code development
2020-08-20 Running SPI example between FGPA and MCU
2020-09-06 SCPI commands define.
2020-09-22 ADC shows signs of life.
2020-09-28 Software development.
2020-09-29 Rebuiled the main control structure.
2020-09-30 EEPROM function works now. Using ee24 lib from https://github.com/nimaltd/ee24
2020-10-01 Fixed bugs in schematic and PCB. Software development.
2020-10-02 Software development
2020-10-04 Part of the switching path works. Fixed problem with ADC circuit (bad solder).
