# Repository mfkiwl/ETH1CDMM1ice40hx-stm32h7

## KiCad design doc/pcb/2_adc.kicad_pcb

Board: 2 copper layers, 95.0 x 85.0 mm, 80 parts (0 on the bottom side), 79 nets.

Parts:
C1, C6: 1u; R0805
C2, C3, C4, C5, C23: 47u; SMC_C
C7: 100n; C050-035X075
C8: 2n2; C150-054X183
C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C24: 100n; R0805
D1: 1N4148; SOD-80
IC1: 78T; TO220H
IC2: 7905; TO220H
IC3: TL7712; SO08
IC4: LM399H; TO39_4
IC5: DG211CJD; SO16
IC6: DG419DJD; SO08
IC7: OPA140; SO08
IC8: TL071D; SO08
IC9: AD8676; SO08
IC10: LT1116; SO-08
IC11: EPM240T100C5N; QFP50P1600X1600X120-100N
JP1: PINHD-1X06_2.54; 1X06
LED1, LED2, LED3: LEDCHIPLED_0805; CHIPLED_0805
QG1: SG-615
R1, R2, R3: 10k; R0805
R4: 0; R_TR191
R5: 6k95; R_TR191
R6: 1k96; R_TR191
R7: 3k01; R_TR191
R8, R9, R10, R11, R12, R13: R_0805; R0805
R14, R15, R16: 470; R0805
R17: 0; R0805
SV1, SV2: ML10
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TPB1,27; B1,27
U$1: LT5400-100k-100k; MSOP8-EP
U$2: LT5400-5k-1k; MSOP8-EP
U$3: LT5400-10k+10k; MSOP8-EP
X1, X5: 22-23-2061
X2, X3: 22-23-2021
X4: 22-23-2041

Connections:
+3V3: C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.+, C24.2, IC11.9, IC11.13, IC11.31, IC11.45, IC11.59, IC11.63, IC11.80, IC11.94, QG1.4, SV1.9, SV2.4, X1.2, X4.3, X5.5
+5V: C4.+, C12.2, IC1.3, IC5.12, IC6.5, IC10.1
+12V: C2.+, C9.2, C10.2, C11.2, C14.2, C15.2, IC1.1, IC3.7, IC3.8, IC4.3, IC5.13, IC6.4, IC7.7, IC8.7, IC9.8, R1.2, X1.3
-5V: C5.-, C13.2, IC2.3, IC10.4
-12V: C3.-, C10.1, C11.1, C14.1, C15.1, IC2.2, IC5.4, IC6.7, IC7.4, IC9.4, X1.6
/ADC_IN: U$1.1, X2.2
/COMP: IC10.7, R13.2
/SW_ID: IC5.16, R11.2
/SW_IIN: IC5.1, R10.2
/SW_IR+: IC5.8, R9.2
/SW_IR-: IC5.9, R12.2
/SW_VRH: IC6.6, R8.2
/VREF+: IC9.1, IC9.2, U$1.4, U$3.3, U$3.4
/VREF-: IC9.7, U$1.3, U$3.1, U$3.2
DGND: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.-, C24.1, IC11.10, IC11.11, IC11.32, IC11.46, IC11.60, IC11.65, IC11.79, IC11.93, QG1.2, R14.2, R15.2, R16.2, R17.2, SV1.10, SV2.2, SV2.10, X1.1, X4.4, X5.6
GND: C1.1, C2.-, C3.+, C4.-, C5.+, C6.1, C7.2, C9.1, C12.1, C13.1, IC1.2, IC2.1, IC3.4, IC4.2, IC4.4, IC5.5, IC6.3, IC7.3, IC8.4, IC9.5, IC10.3, IC10.5, IC10.6, R2.1, R5.P$1, R17.1, U$1.EP, U$2.6, U$2.EP, U$3.EP, X1.4, X1.5, X2.1, X3.1
unnamed: C1.2, IC3.3
unnamed: C6.2, IC3.1
unnamed: C7.1, IC6.8, R4.P$1, U$2.5
unnamed: C8.1, IC5.3, IC5.7, IC5.10, IC5.14, IC7.2
unnamed: C8.2, IC5.15, IC7.6, IC10.2
unnamed: D1.A, IC3.6, R2.2
unnamed: D1.K, R3.2
unnamed: IC3.2, R1.1, X3.2
unnamed: IC4.1, IC8.3, R3.1, R4.P$2, R6.P$2
unnamed: IC5.2, U$1.7
unnamed: IC5.6, U$1.5
unnamed: IC5.11, U$1.6
unnamed: IC6.1, IC9.3
unnamed: IC6.2, U$2.7, U$2.8
unnamed: IC8.2, R5.P$2, R7.P$2
unnamed: IC8.6, R6.P$1, R7.P$1
unnamed: IC9.6, U$3.5, U$3.6, U$3.7, U$3.8
unnamed: IC11.1, SV1.1
unnamed: IC11.2, SV1.2
unnamed: IC11.3, SV1.3
unnamed: IC11.4, SV1.4
unnamed: IC11.5, SV1.5
unnamed: IC11.6, SV1.6
unnamed: IC11.7, SV1.7
unnamed: IC11.8, SV1.8
unnamed: IC11.12, X4.1
unnamed: IC11.14, QG1.3
unnamed: IC11.15, X4.2
unnamed: IC11.18, X5.1
unnamed: IC11.19, X5.2
unnamed: IC11.20, X5.3
unnamed: IC11.21, X5.4
unnamed: IC11.22, SV2.5
unnamed: IC11.23, SV2.9
unnamed: IC11.24, SV2.1
unnamed: IC11.25, SV2.3
unnamed: IC11.33, LED1.A
unnamed: IC11.34, LED3.A
unnamed: IC11.35, LED2.A
unnamed: IC11.36, TP4.TP
unnamed: IC11.37, TP5.TP
unnamed: IC11.38, TP6.TP
unnamed: IC11.48, TP3.TP
unnamed: IC11.49, TP1.TP
unnamed: IC11.50, TP2.TP
unnamed: IC11.51, R8.1
unnamed: IC11.53, R9.1
unnamed: IC11.54, R10.1
unnamed: IC11.55, R11.1
unnamed: IC11.56, R12.1
unnamed: IC11.58, R13.1
unnamed: JP1.1, TP7.TP
unnamed: JP1.2, TP8.TP
unnamed: JP1.3, TP9.TP
unnamed: JP1.4, TP10.TP
unnamed: JP1.5, TP11.TP
unnamed: JP1.6, TP12.TP
unnamed: LED1.C, R16.1
unnamed: LED2.C, R14.1
unnamed: LED3.C, R15.1
unnamed: U$1.2, U$1.8
unnamed: U$2.1, U$2.4
unnamed: U$2.2, U$2.3

## KiCad design hardware/project/ETH1CDMM1/ETH1CDMM1.kicad_pcb

Parts:
C201, C204: 8p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C202, C205, C208, C209, C210, C211, C212: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C203: 470p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C206, C207: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C213, C214: 1n/1kV; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D201: YELLOW; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D202: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB201: 742792031; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
L201: 749010012A
R201, R202, R204, R205: 33; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R203, R206, R207, R208, R209, R211: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R210: 1k5; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R212: 12k1; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R213, R214: 270; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R215, R216, R217, R218: 49R9; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R219: 1M/1kV; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R220, R221: 75/1%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U201: LAN8742A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
U202, U203: LC03-3.3; SO8E
Y201: NX5032GA-25.000M-LN-CD-1; NX5032GA

Connections:
+3.3VF: C202.1, C205.1, FB201.2, R206.1, R207.1, R208.1, R209.1, R210.1, U201.9 (VDDIO); also elsewhere on the board
/Connector/RX+: U203.8; also elsewhere on the board
/Connector/RX-: U203.5; also elsewhere on the board
/Connector/TX+: U202.8; also elsewhere on the board
/Connector/TX-: U202.5; also elsewhere on the board
/Ethernet/ETH_RXN: L201.8 (RD-), R218.2, U201.22 (RXN)
/Ethernet/ETH_RXP: L201.6 (RD+), R217.2, U201.23 (RXP)
/Ethernet/ETH_TXN: L201.3 (TD-), R216.2, U201.20 (TXN)
/Ethernet/ETH_TXP: L201.1 (TD+), R215.2, U201.21 (TXP)
/Ethernet/MODE0: R201.1, R206.2, U201.8 (RXD0/MODE0)
/Ethernet/MODE1: R202.1, R207.2, U201.7 (RXD1/MODE1)
/Ethernet/MODE2: R204.1, R208.2, U201.11 (CRS_DV/MODE2)
/Ethernet/NRST: U201.15 (~RST); also elsewhere on the board
/Ethernet/REFCLK0: R205.1, R209.2, U201.14 (~INT/REFCLK0)
/Ethernet/REF_CLK: R205.2; also elsewhere on the board
/Ethernet/RMII_CRS_DV: R204.2; also elsewhere on the board
/Ethernet/RMII_MDC: U201.13 (MDC); also elsewhere on the board
/Ethernet/RMII_MDIO: R210.2, U201.12 (MDIO); also elsewhere on the board
/Ethernet/RMII_RXD0: R201.2; also elsewhere on the board
/Ethernet/RMII_RXD1: R202.2; also elsewhere on the board
/Ethernet/RMII_TXD0: U201.17 (TXD0); also elsewhere on the board
/Ethernet/RMII_TXD1: U201.18 (TXD1); also elsewhere on the board
/Ethernet/RMII_TXEN: U201.16 (TXEN); also elsewhere on the board
Earth: C213.1, C214.2, R219.1; also elsewhere on the board
unnamed: C201.1, U201.5 (XTAL1/CLKIN), Y201.2
unnamed: C203.1, C206.1, U201.6 (VDDCR)
unnamed: C204.1, U201.4 (XTAL2), Y201.1
unnamed: C214.1, R220.2, R221.2
unnamed: D201.1 (K), R213.1
unnamed: D201.2 (A), R211.1, U201.2 (LED2/~INTSEL)
unnamed: D202.1 (K), R214.1
unnamed: D202.2 (A), U201.3 (LED1/REGOFF)
unnamed: L201.9 (RX-), U203.4
unnamed: L201.10 (CRX), R220.1
unnamed: L201.11 (RX+), U203.1
unnamed: L201.14 (TX-), U202.4
unnamed: L201.15 (CTX), R221.1
unnamed: L201.16 (TX+), U202.1
unnamed: R203.1, U201.10 (RXER/PHYAD0)
unnamed: R212.2, U201.24 (RBIAS)
VCCQ: C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, FB201.1, L201.2 (CTD), L201.7 (CRD), R215.1, R216.1, R217.1, R218.1, U201.1 (VDD2A), U201.19 (VDD1A)

Parts:
C301, C302: 4u7/50V; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C303, C304: 330p/2kV; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
D301: SM6T30AY; DO_214AA_REV
D302: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D303: MMSZ5249B; D_SOD-123
F301: MF-LSMF185/33X; Fuse_SMD2920
L301: 7448014501
Q301: IRFR5410; TO-252-2_Rectifier
R301: 100k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R302: 6k8/0.5W; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R303: 370; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R304, R305: OPT; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U301: MAX5902; SOT-23-6_Handsoldering
U302: THL15-2415WI; THL15

Connections:
+24V: F301.2; also elsewhere on the board
+24VF: C303.1, R304.1, U302.3 (+VOUT); also elsewhere on the board
GNDPWR: C301.2, C302.2, D301.2 (A), D302.1 (K), L301.1, U301.4 (GND); also elsewhere on the board
unnamed: C301.1, C302.1, D303.1 (K), L301.2, Q301.2 (D), R302.1, U301.2 (DRAIN)
unnamed: C303.2, L301.3, U302.1 (+VIN)
unnamed: C304.2, L301.4, U302.2 (-VIN)
unnamed: D301.1 (K), F301.1, Q301.3 (S), R301.1, U301.1 (VS)
unnamed: D302.2 (A), R302.2, R303.2
unnamed: D303.2 (A), R303.1
unnamed: Q301.1 (G), U301.3 (GATE)
unnamed: R301.2, U301.6 (ON/~OFF)
unnamed: R304.2, R305.1, U302.4 (TRIM)

Parts:
C401, C402, C404, C405, C416, C419, C424, C427: 10u/50V; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C403, C434: 10u/16V; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C406, C422, C428, C429: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C407, C408, C420, C421, C425, C426, C430, C431: 4u7/50V; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C409, C439: 47u/16V; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C410, C411, C432, C433: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C412, C413: 1u/HC; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C414, C415, C437, C438: 10n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C417, C418: 4p7; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C423: 4u7; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C435, C436: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D401, D402: PMEG6010EP,115; D_SOD-128
L401, L404: TCK-141
L402, L403: 74489440068
R401, R402, R404, R406, R407, R409: 1M; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R403, R405: 287k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R408, R410: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R411: 357k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R412: 210k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R413, R414: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R415, R416: 0R1; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U401: TSR1-2490; TSR1
U402: LM1117DTX-5.0/NOPB; TO-252-2
U403, U404: LT8330_S6; TSOT-23-6_HandSoldering
U405: LT3030; ETSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP3x4.2mm
U406: MC7815BD2TG; TO-263-2
U407: MC7915BD2TG; TO-263-2
U408: TSR2-2450; TSR2
U409: LM1117DTX-3.3/NOPB; TO-252-2

Connections:
+1V2: C429.1, C433.1, C436.1, C438.1, R416.1; also elsewhere on the board
+3.3VF: C439.1, U409.2 (VO); also elsewhere on the board
+3.3VP: C428.1, C432.1, C435.1, C437.1, R415.1; also elsewhere on the board
+24VF: C401.1, C404.1, C405.1, C407.1, C408.1, C416.1, C419.1, L401.1, L402.1, L403.1, L404.1, R402.1, R404.1, U403.6 (VIN), U404.6 (VIN); also elsewhere on the board
unnamed: C402.1, L401.2, U401.1 (VI)
unnamed: C403.1, C406.1, R401.1, R406.1, U401.3 (VO), U402.3 (VI), U405.11 (~SHDN2), U405.13 (IN), U405.14 (IN), U405.17 (IN), U405.18 (IN), U405.20 (~SHDN1)
unnamed: C410.1, U403.5 (INTVCC)
unnamed: C411.1, U404.5 (INTVCC)
unnamed: C412.1, D402.2 (A), L402.2
unnamed: C412.2, L402.4, U403.1 (SW)
unnamed: C413.1, D401.2 (A), L403.2
unnamed: C413.2, L403.4, U404.1 (SW)
unnamed: C414.1, C422.1, R411.1, R413.1, R415.2, U405.3 (OUT1), U405.4 (OUT1)
unnamed: C414.2, U405.2 (BYP1)
unnamed: C415.1, C423.1, R414.1, R416.2, U405.7 (OUT2), U405.8 (OUT2), U405.10 (ADJ2)
unnamed: C415.2, U405.9 (BYP2)
unnamed: C417.1, C420.1, C425.1, D402.1 (K), R407.1, U406.1 (IN)
unnamed: C417.2, R407.2, R408.1, U403.3 (FBX)
unnamed: C418.1, C421.1, C426.1, L403.3, R409.1, U407.2 (VI)
unnamed: C418.2, R409.2, R410.1, U404.3 (FBX)
unnamed: C424.1, C427.1, L404.2, U408.1 (VI)
unnamed: C434.1, U408.3 (VO), U409.3 (VI)
unnamed: R401.2, U405.12 (PWRGD2)
unnamed: R402.2, R403.1, U403.4 (EN/UVLO)
unnamed: R404.2, R405.1, U404.4 (EN/UVLO)
unnamed: R406.2, U405.19 (PWRGD1)
unnamed: R411.2, R412.2, U405.1 (ADJ1)

Parts:
C501, C503, C504, C506, C508: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C502, C505, C507: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C509: 47p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D501: BAV99; SOT-23
D502: SMBJ5.0A; D_SMB
D503: SD36C-01FTG; D_SOD-323_HandSoldering
L501: CW252016-R33G; CW252016
R501: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R502: 14k7; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R503: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R504: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R505: 47; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R506: 51R1; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U501: TXB0104PW; TSSOP-14_4.4x5mm_P0.65mm
U502: ADuM5402; SOIC-16W_7.5x10.3mm_P1.27mm
U503: 74AC125; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3.3VF: C501.1, C502.1, R501.1, U501.1 (VCCA); also elsewhere on the board
+5V_TRIG: C506.1, C507.1, C508.1, R504.1, U502.10 (VSEL), U502.16 (VISO), U503.14 (VCC)
/Connector/EXT_TRIG: C509.1, D503.1 (A1), L501.1; also elsewhere on the board
/MCU/TRIG_EN: U501.2 (A1); also elsewhere on the board
/MCU/TRIG_IN: U501.4 (A3); also elsewhere on the board
/MCU/TRIG_OUT: U501.3 (A2); also elsewhere on the board
/Trigger/EXT_TRIG_SIGN: R502.1, U502.12 (VIC), U503.3 (O)
/Trigger/TRIG_OUT_EN: U502.14 (VOA), U503.4 (EN), U503.10 (EN), U503.13 (EN)
/Trigger/TRIG_OUT_SIGN: U502.13 (VOB), U503.5 (D), U503.9 (D), U503.12 (D)
GND_TRIG: C506.2, C507.2, C508.2, D501.1 (K), D502.2 (A), D503.2 (A2), R506.2, U502.9 (GNDISO), U502.15 (GNDISO), U503.1 (EN), U503.7 (GND); also elsewhere on the board
unnamed: C509.2, R506.1
unnamed: D501.2 (A), D502.1 (K), R504.2
unnamed: D501.3 (K), R503.2, R505.1, U503.6 (O), U503.8 (O), U503.11 (O)
unnamed: L501.2, R505.2
unnamed: R501.2, U501.8 (OE)
unnamed: R502.2, R503.1, U503.2 (D)
unnamed: U501.11 (B3), U502.5 (VOC)
unnamed: U501.12 (B2), U502.4 (VIB)
unnamed: U501.13 (B1), U502.3 (VIA)
