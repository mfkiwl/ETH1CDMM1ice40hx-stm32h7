# Repository mfkiwl/ETH1CDMM1ice40hx-stm32h7 (continued)

## KiCad design hardware/project/ETH1CDMM1/ETH1CDMM1.kicad_pcb (continued)

Parts:
C601, C602, C603, C604, C605, C606, C607, C608, C609, C610, C611, C612, C613, C614, C615, C617, C619: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C616, C618: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D601: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D602: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D603: CDBU0520; D_SOD-523
J601: Conn_02x05; PinHeader_2x05_P2.54mm_Vertical
R601, R608, R611: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R602, R603, R604, R605, R606, R607, R610: 150; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R609: 200; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R612, R617: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R613, R614, R615, R618, R619, R620: 4k7; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R616: OPT; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U601: ICE40HX4K-TQ144; TQFP-144_20x20mm_P0.5mm
U602: ASDMB-100.000MHZ; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm
U603: SN74LVC1T45DBV; SOT-23-6
U604: MT25QL128ABA1ESE; SOIC-8_5.23x5.23mm_P1.27mm

Connections:
+1V2: C602.1, C605.1, C607.1, C609.1, R612.2, R617.2, U601.27 (VCC), U601.40 (VCC), U601.92 (VCC), U601.111 (VCC); also elsewhere on the board
+3.3VP: C601.1, C603.1, C604.1, C606.1, C608.1, C610.1, C611.1, C612.1, C613.1, C614.1, C615.1, D603.2 (A), R613.2, R614.2, R615.2, R618.1, R619.1, R620.1, U601.6 (VCCIO_3), U601.30 (VCCIO_3), U601.46 (VCCIO_2), U601.57 (VCCIO_2), U601.72 (VCC_SPI), U601.89 (VCCIO_1), U601.100 (VCCIO_1), U601.123 (VCCIO_0), U601.131 (VCCIO_0), U602.1 (Standby), U602.4 (VDD), U603.6 (VCCB), U604.8 (VCC); also elsewhere on the board
/ADC/ADC_COMP: R610.1, U603.3 (A); also elsewhere on the board
/ADC/FGPA_SW_ID: R603.2; also elsewhere on the board
/ADC/FGPA_SW_IN: R605.2; also elsewhere on the board
/ADC/FGPA_SW_IR+: R604.2; also elsewhere on the board
/ADC/FGPA_SW_IR-: R602.2; also elsewhere on the board
/ADC/FPGA_ADC_~RST: R607.2; also elsewhere on the board
/ADC/FPGA_SW_VRH: R606.2; also elsewhere on the board
/FPGA/100MHZ: R609.1, U601.129 (IOT_198_GBIN0)
/FPGA/COMP: R610.2, U603.4 (B)
/FPGA/FPGA_IO1: U601.80 (IOR_116); also elsewhere on the board
/FPGA/FPGA_IO2: U601.81 (IOR_117); also elsewhere on the board
/FPGA/FPGA_SPI1_MISO: U601.78 (IOR_114); also elsewhere on the board
/FPGA/FPGA_SPI1_MOSI: U601.76 (IOR_112); also elsewhere on the board
/FPGA/FPGA_SPI1_NSS: U601.79 (IOR_115); also elsewhere on the board
/FPGA/FPGA_SPI1_SCK: U601.75 (IOR_111); also elsewhere on the board
/FPGA/FPGA_UART2_RX_TTL: U601.74 (IOR_110); also elsewhere on the board
/FPGA/FPGA_UART2_TX_TTL: U601.73 (IOR_109); also elsewhere on the board
/FPGA/GNDPLL0: C618.2, C619.2, U601.53 (GNDPLL0)
/FPGA/GNDPLL1: C616.2, C617.2, U601.127 (GNDPLL1)
/FPGA/VCCPLL0: C618.1, C619.1, R617.1, U601.54 (VCCPLL0)
/FPGA/VCCPLL1: C616.1, C617.1, R612.1, U601.126 (VCCPLL1)
/FPGA/iCE_CDONE: J601.5, R618.2, U601.65 (CDONE)
/FPGA/iCE_CRESET: J601.6, R613.1, R616.1, U601.66 (~CRESET)
/FPGA/iCE_MISO: J601.8, U601.67 (IOB_105_SDO), U604.5 (DQ0)
/FPGA/iCE_MOSI: J601.7, U601.68 (IOB_106_SDI), U604.2 (DQ1)
/FPGA/iCE_Rx_TTL: J601.3, U601.112 (IOT_169)
/FPGA/iCE_SCK: J601.9, R619.2, U601.70 (IOB_107_SCK), U604.6 (C)
/FPGA/iCE_SS_B: J601.10, R620.2, U601.71 (IOB_108_SS), U604.1 (S#)
/FPGA/iCE_Tx_TTL: J601.4, U601.110 (IOT_168)
unnamed: D601.2 (A), R601.2
unnamed: D602.2 (A), R608.2
unnamed: D603.1 (K), U601.108 (VPP_2V5)
unnamed: R601.1, U601.37 (IOB_56)
unnamed: R602.1, U601.1 (IOL_2A)
unnamed: R603.1, U601.2 (IOL_2B)
unnamed: R604.1, U601.3 (IOL_3A)
unnamed: R605.1, U601.4 (IOL_3B)
unnamed: R606.1, U601.7 (IOL_4A)
unnamed: R607.1, U601.8 (IOL_4B)
unnamed: R608.1, U601.38 (IOB_57)
unnamed: R609.2, U602.3 (Out)
unnamed: R611.2, U603.5 (DIR)
unnamed: R614.1, U604.3 (W#/DQ2)
unnamed: R615.1, U604.7 (DQ3/HOLD#)

Parts:
C701, C703: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C702, C704, C705, C706, C707, C708, C709, C710, C711, C712: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C713: 2n2; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C714: 220n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D701: 1N4148W; D_SOD-123
D702: TFZVTR5.1B; D_SOD-323HE
R701, R703, R705: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R702: 0; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R704: 6k95/.05%; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R706: 3k01/.1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R707: 1k96/.1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R708: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R709: 1k5; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U701: DG211CJD; TSSOP-16_4.4x5mm_P0.65mm
U702, U708: TL071; SOIC-8_3.9x4.9mm_P1.27mm
U703: AD8676; SOIC-8_3.9x4.9mm_P1.27mm
U704: LM399H; LMx99
U705: LT5400-5k-1k; MSOP-8-1EP_3x3mm_P0.65mm_EP1.73x1.85mm_ThermalVias
U706: TL7712A; SOIC-8_3.9x4.9mm_P1.27mm
U707: DG419xY; SOIC-8_3.9x4.9mm_P1.27mm
U709: LT5400-10k-10k; MSOP-8-1EP_3x3mm_P0.65mm_EP1.73x1.85mm_ThermalVias
U710: LT5400-100k-100k; MSOP-8-1EP_3x3mm_P0.65mm_EP1.73x1.85mm_ThermalVias
U711: OPA140; SOIC-8_3.9x4.9mm_P1.27mm
U712: LT1116; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/ADC/+7VREF: C702.1, R702.1, U705.5, U707.8
/ADC/+10VREF: R708.1; also elsewhere on the board
/ADC/-7VREF: U702.3 (+), U702.6; also elsewhere on the board
/ADC/ADC_COMP: U712.7 (Q); also elsewhere on the board
/ADC/ADIN: U710.1; also elsewhere on the board
/ADC/FGPA_SW_ID: U701.16; also elsewhere on the board
/ADC/FGPA_SW_IN: U701.1; also elsewhere on the board
/ADC/FGPA_SW_IR+: U701.8; also elsewhere on the board
/ADC/FGPA_SW_IR-: U701.9; also elsewhere on the board
/ADC/FPGA_ADC_~RST: R701.2, U706.2 (~RESIN); also elsewhere on the board
/ADC/FPGA_SW_VRH: U707.6; also elsewhere on the board
/ADC/VREF+: U703.1, U703.2 (-), U709.3, U709.4, U710.4
/ADC/VREF-: U703.7, U709.1, U709.2, U710.3
unnamed: C701.1, U706.3 (CT)
unnamed: C703.1, U706.1 (REF)
unnamed: D701.1 (K), R705.1
unnamed: D701.2 (A), R703.1, U706.6 (RESET)
unnamed: R702.2, R705.2, R707.2, U702.2 (-), U704.1, U708.3 (+)
unnamed: R704.1, R706.2, U708.2 (-)
unnamed: R706.1, R707.1, R708.2, U708.6
unnamed: U701.2, U710.7
unnamed: U701.6, U710.5
unnamed: U701.11, U710.6
unnamed: U703.3 (+), U707.1
unnamed: U703.6 (-), U709.5, U709.6, U709.7, U709.8
unnamed: U705.1, U705.4
unnamed: U705.2, U705.3
unnamed: U705.7, U705.8, U707.2
unnamed: U710.2, U710.8

Notes on the sheet:
6k98 - ERA-8ARW6981V 3k01 - RQ73C2A3K01BTDF 1k96 - RN73C2A1K96BTDF

Parts:
C801, C802: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C803, C804: 220p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C805: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D801: ABS10; Diode_Bridge_Diotec_ABS
E801: CG3-1.5L; GDT
F801: 0ZCF0100AF2A; Fuse_2920_7451Metric_Pad2.10x5.45mm_HandSolder
R801, R802, R803, R804, R805, R808: 24k/200V/.5W/.25%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R806, R807: 1M/400V/.5W; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R809: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R810: 316; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
RV801, RV802: B72660M0301K072; 4032
U801: OPA132; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/Connector/H: E801.1; also elsewhere on the board
/Connector/HS: R801.1; also elsewhere on the board
/Connector/I: F801.1, RV801.1; also elsewhere on the board
/Connector/LS: R802.1; also elsewhere on the board
/Function Selection/AMPS: D801.4 (~~), F801.2, R809.2; also elsewhere on the board
/Function Selection/HI_SENSE: C803.1, R805.2; also elsewhere on the board
/Function Selection/LO_SENSE: C804.1, R808.2; also elsewhere on the board
unnamed: C805.1, E801.2, R806.1, RV802.1
unnamed: D801.1 (+), D801.2 (-), R810.2
unnamed: R801.2, R803.1
unnamed: R802.2, R804.1
unnamed: R803.2, R805.1
unnamed: R804.2, R808.1
unnamed: R806.2, R807.1
unnamed: R809.1, U801.3 (+)
unnamed: R810.1, U801.2 (-), U801.6

Schematic: Function_Selection.sch

Parts:
C901: 470p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C902: 220p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D901, D902, D903: 1N4148W; D_SOD-123
K901, K902, K903: TQ2SA-5V; SA
L901, L902: CBC3225T102MR; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
L903, L904, L905: L0805R100MPWRT; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R901, R902: 3k16; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R903, R911: 6k19/150V; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R904, R905, R906, R907, R910, R912, R915, R917: 13k/150V; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R908: 5; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R909: PCS2512DR1000ET; R_2512_6332Metric_Pad1.52x3.35mm_HandSolder
R913, R916, R918, R919: 2M2/150V; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R914, R921, R923: 100k/150V; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R920: 1M1/150V; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R922, R924: 24k/150V; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R925, R926, R927, R928, R929, R930, R931, R932, R933: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U901: MCZ33996; HSOP-32-1EP_7.5x11.0mm_P0.65mm_ThermalVias
U902, U903, U904, U905: AQW212S; GU-SOP8
U906: AQY212GS

Connections:
+3.3VF: U901.3 (SOPWR); also elsewhere on the board
/Connector/H: L901.1, L903.1, R901.1; also elsewhere on the board
/DC Amplifier/AMP+: U905.5, U905.7; also elsewhere on the board
/Function Selection/4W_HI_CTR: U901.13 (OUT5), U902.4
/Function Selection/4W_LO_CTR: U901.17 (OUT8), U903.2
/Function Selection/AMPS: K902.3; also elsewhere on the board
/Function Selection/AMPS_CTR: U901.15 (OUT6), U902.2
/Function Selection/DCV_A_CTR: U901.18 (OUT9), U906.2
/Function Selection/DCV_H_CTR: U901.12 (OUT4), U904.2
/Function Selection/DCV_L_CTR: U901.5 (OUT3), U904.4
/Function Selection/HI_SENSE: R922.2; also elsewhere on the board
/Function Selection/LO_SENSE: R924.2; also elsewhere on the board
/Function Selection/L_RLY: D901.2 (A), K901.1, U901.1 (OUT0)
/Function Selection/MC_CTR: U901.21 (OUT11), U905.2
/Function Selection/MZ_CTR: U901.20 (OUT10), U905.4
/Function Selection/OHMS_CURRENT: K902.8; also elsewhere on the board
/Function Selection/SLE_SCLK: U901.11 (SCLK); also elsewhere on the board
/Function Selection/SLE_SI: U901.19 (SI); also elsewhere on the board
/Function Selection/SLE_SO: U901.22 (SO); also elsewhere on the board
/Function Selection/SLE_~CS: U901.14 (~CS); also elsewhere on the board
/Function Selection/SLE_~RST: U901.27 (~RST); also elsewhere on the board
/Function Selection/VZERO_CTR: U901.16 (OUT7), U903.4
/Function Selection/XH_RLY: D903.2 (A), K903.1, U901.2 (OUT1)
/Function Selection/XO-A_RLY: D902.2 (A), K902.1, U901.4 (OUT2)
unnamed: C901.1, R912.1, R915.2
unnamed: C902.1, L904.1, R917.1
unnamed: K901.3, R904.2
unnamed: K901.4, K901.9, L903.2, R903.1
unnamed: K902.2, R908.2, R909.1
unnamed: K902.4, R908.1, R914.2
unnamed: K902.9, L902.2, R902.2
unnamed: K903.3, R911.2
unnamed: K903.4, R903.2
unnamed: L901.2, L902.1, R901.2, R902.1
unnamed: L904.2, L905.1
unnamed: L905.2, U904.6
unnamed: R904.1, R905.2
unnamed: R905.1, R906.2
unnamed: R906.1, R907.2
unnamed: R907.1, R910.2
unnamed: R910.1, R912.2
unnamed: R911.1, R913.2
unnamed: R913.1, R916.2
unnamed: R914.1, U902.8
unnamed: R915.1, R917.2
unnamed: R916.1, R918.2
unnamed: R918.1, R919.2
unnamed: R919.1, R920.2
unnamed: R920.1, R921.1, U904.8
unnamed: R922.1, U902.6
unnamed: R923.1, U903.6
unnamed: R924.1, U903.8
unnamed: R925.2, U902.3
unnamed: R926.2, U902.1
unnamed: R927.2, U903.3
unnamed: R928.2, U903.1
unnamed: R929.2, U904.3
unnamed: R930.2, U904.1
unnamed: R931.2, U905.1
unnamed: R932.2, U905.3
unnamed: R933.2, U906.1
unnamed 349: U906.6; also elsewhere on the board
unnamed 350: U906.5; also elsewhere on the board
unnamed 351: U906.3; also elsewhere on the board
unnamed 352: U906.4; also elsewhere on the board
unnamed: U902.5, U904.5, U904.7, U905.8, U906.8
unnamed: U902.7, U906.7
unnamed: U903.5, U903.7, U905.6

Parts:
C1001: 10p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C1002: C; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C1003, C1004, C1005, C1006, C1007, C1008, C1009, C1010, C1011, C1012, C1013, C1014, C1015, C1016, C1017, C1018, C1019, C1020, C1021, C1022, C1023: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1001: 1N4148W; D_SOD-123
K1001: 9012
Q1001: BC847W; SOT-323_SC-70
Q1002, Q1003, Q1004, Q1005: MMBT6429; SOT-23
Q1006: MMBF4392LT1G; SOT-23
Q1007: IFN411; TO-71
R1001: 14k7; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1002, R1006, R1007: 21k5; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1003, R1013, R1017, R1018: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1004: 10M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1005: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1008: DNP; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1009: 500; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1010, R1014: 180k/.05%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1011, R1015: 18k/.05%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1012, R1016: 2k/.05%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1019: 8k25; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1001, U1002: AD706; SOIC-8_3.9x4.9mm_P1.27mm
U1003, U1004: DG419LDY; SOIC-8_3.9x4.9mm_P1.27mm
U1005: MORNTA2001QT5; MSOP-8_3x3mm_P0.65mm
U1006, U1011: TMUX6104; TSSOP-14_4.4x5mm_P0.65mm
U1007: OPA140; SOIC-8_3.9x4.9mm_P1.27mm
U1008: AD711; SOIC-8_3.9x4.9mm_P1.27mm
U1009, U1012: TXB0104PW; TSSOP-14_4.4x5mm_P0.65mm
U1010: OP27; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VF: C1008.1, C1009.1, R1013.1, R1018.1, U1009.1 (VCCA), U1012.1 (VCCA); also elsewhere on the board
/ADC/+10VREF: R1001.2; also elsewhere on the board
/ADC/ADIN: U1004.1; also elsewhere on the board
/DC Amplifier/AMP+: U1003.1; also elsewhere on the board
/DC Amplifier/AMPL_SEL: U1003.6, U1004.6; also elsewhere on the board
/DC Amplifier/DC_AMP1_MUX_A0: U1012.2 (A1); also elsewhere on the board
/DC Amplifier/DC_AMP1_MUX_A1: U1012.3 (A2); also elsewhere on the board
/DC Amplifier/DC_AMP1_MUX_EN: U1012.4 (A3); also elsewhere on the board
/DC Amplifier/DC_AMP2_MUX_A0: U1009.2 (A1); also elsewhere on the board
/DC Amplifier/DC_AMP2_MUX_A1: U1009.3 (A2); also elsewhere on the board
/DC Amplifier/DC_AMP2_MUX_EN: U1009.4 (A3); also elsewhere on the board
/DC Amplifier/DC_AMP_10MEG: R1003.1; also elsewhere on the board
/DC Amplifier/MUX1_A0: U1011.1 (A0), U1012.13 (B1)
/DC Amplifier/MUX1_A1: U1011.14 (A1), U1012.12 (B2)
/DC Amplifier/MUX1_EN: U1011.2 (EN), U1012.11 (B3)
/DC Amplifier/MUX2_A0: U1006.1 (A0), U1009.13 (B1)
/DC Amplifier/MUX2_A1: U1006.14 (A1), U1009.12 (B2)
/DC Amplifier/MUX2_EN: U1006.2 (EN), U1009.11 (B3)
unnamed: C1001.1, Q1001.1 (B), R1003.2
unnamed: C1002.1, R1005.1, U1007.3 (+)
unnamed: D1001.2 (A), K1001.3, Q1001.3 (C)
unnamed: K1001.1, R1005.2, U1003.8
unnamed: K1001.4, R1004.1
unnamed: Q1002.1 (B), U1002.7
unnamed: Q1002.2 (E), Q1004.1 (B), R1006.1
unnamed: Q1002.3 (C), Q1004.3 (C), Q1007.1, U1008.3 (+), U1010.3 (+)
unnamed: Q1003.1 (B), U1002.1
unnamed: Q1003.2 (E), Q1005.1 (B), R1007.1
unnamed: Q1003.3 (C), Q1005.3 (C), Q1007.5, U1010.2 (-)
unnamed: Q1004.2 (E), R1006.2, U1002.6 (-), U1005.7
unnamed: Q1005.2 (E), R1007.2, U1002.2 (-), U1005.6
unnamed: Q1006.1 (S), Q1007.2, Q1007.6
unnamed: Q1006.3 (G), U1008.2 (-), U1008.6
unnamed: Q1007.3, U1003.2
unnamed: Q1007.7, U1011.6 (D)
unnamed: R1001.1, R1002.2, U1001.6 (-)
unnamed: R1002.1, U1002.3 (+), U1002.5 (+), U1005.8
unnamed: R1008.1, R1009.1, R1010.1, U1004.8, U1007.6
unnamed: R1008.2, U1006.6 (D), U1007.2 (-)
unnamed: R1009.2, U1006.4 (S1), U1006.5 (S2)
unnamed: R1010.2, R1011.1, U1006.11 (S3)
unnamed: R1011.2, R1012.1, U1006.10 (S4)
unnamed: R1013.2, U1009.8 (OE)
unnamed: R1014.1, R1017.2, U1010.6, U1011.4 (S1), U1011.5 (S2)
unnamed: R1014.2, R1015.1, U1011.11 (S3)
unnamed: R1015.2, R1016.1, U1011.10 (S4)
unnamed: R1017.1, R1019.2, U1001.2 (-), U1004.2
unnamed: R1018.2, U1012.8 (OE)
unnamed: R1019.1, U1001.1
unnamed: U1001.7, U1005.1, U1005.2, U1005.3
unnamed: U1005.4, U1005.5

Notes on the sheet:
180k - RG2012N-184-W-T1 18k - ERA-6ARW183V 2k - PLT0805Z2001AST5

Schematic: Ohm_Current_Source.sch

Parts:
C1101, C1102, C1103, C1104, C1105, C1106: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C1107: 220n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1101: TFZVTR5.1B; D_SOD-323HE
D1102, D1103: 1N4148W; D_SOD-123
D1104: S1M; D_SMA
Q1101, Q1103, Q1107, Q1108: CMPF4393; SOT-23
Q1102: MMBT3904; SOT-23
Q1104, Q1105, Q1106: FMMT6520; SOT-23
R1101: 100/.05%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1102: 4k7; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1103, R1118: 5k6; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1104: 54k6; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1105, R1108: 19k6/.05%; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R1106: 505k/.1%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1107: 300/.05%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1109: 576k/1%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1110: 4M99/1%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1111: 33k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1112: 30k/.05%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1113: 1k5/%1; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1114: 15k/.05%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1115: 2k4; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1116: 910; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1117: 523/.1%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1119: 5k/.05%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1120: 5M/0.1%; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R1121: 4M3/1%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1122, R1123, R1124: 33k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1101: OP27; SOIC-8_3.9x4.9mm_P1.27mm
U1102: ADG1414BRU; TSSOP-24_4.4x7.8mm_P0.65mm
U1103: OP07; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VF: C1106.1, R1102.1, U1102.23 (VL); also elsewhere on the board
/ADC/-7VREF: R1101.2; also elsewhere on the board
/Function Selection/OHMS_CURRENT: D1104.2 (A), Q1106.3 (C), R1124.1; also elsewhere on the board
/MCU/OCS_DIN: U1102.3 (DIN); also elsewhere on the board
/MCU/OCS_SCLK: U1102.1 (SCLK); also elsewhere on the board
/MCU/OCS_SDO: R1102.2, U1102.22 (SDO); also elsewhere on the board
/MCU/OCS_~SYNC: U1102.24 (~SYNC); also elsewhere on the board
/MCU/OSC_HV_PROT: R1111.2; also elsewhere on the board
unnamed: C1107.1, D1101.2 (A), R1113.1, U1103.4 (V-)
unnamed: D1102.2 (A), D1103.2 (A), U1103.6
unnamed: D1103.1 (K), R1108.1, R1119.1, R1120.2, R1121.2
unnamed: D1104.1 (K), Q1107.3 (G), Q1108.1 (D), Q1108.2 (S)
unnamed: Q1101.1 (D), U1102.5 (S1), U1102.7 (S2)
unnamed: Q1101.2 (S), R1104.1, U1101.2 (-)
unnamed: Q1101.3 (G), U1101.6
unnamed: Q1102.1 (B), R1111.1
unnamed: Q1102.3 (C), R1116.2, R1118.1
unnamed: Q1103.1 (D), Q1103.2 (S), Q1104.1 (B), R1122.2
unnamed: Q1104.2 (E), R1120.1, U1102.13 (D5), U1102.15 (D6), U1102.17 (D7), U1102.19 (D8)
unnamed: Q1104.3 (C), Q1105.2 (E)
unnamed: Q1105.1 (B), R1122.1, R1123.2
unnamed: Q1105.3 (C), Q1106.2 (E)
unnamed: Q1106.1 (B), R1123.1, R1124.2
unnamed: Q1107.1 (D), Q1107.2 (S), R1115.2, R1116.1
unnamed: R1101.1, R1104.2
unnamed: R1103.1, U1101.3 (+)
unnamed: R1105.1, R1108.2, U1102.6 (D1)
unnamed: R1105.2, R1110.2, U1102.8 (D2), U1102.9 (S3)
unnamed: R1106.1, R1107.2
unnamed: R1106.2, U1102.12 (D4), U1102.16 (S6)
unnamed: R1107.1, R1112.2, U1102.18 (S7)
unnamed: R1109.1, R1110.1, U1103.2 (-)
unnamed: R1109.2, U1102.10 (D3)
unnamed: R1112.1, R1114.2
unnamed: R1114.1, R1117.2
unnamed: R1117.1, R1119.2, U1102.20 (S8)
unnamed: U1102.11 (S4), U1102.14 (S5), U1103.3 (+)

Notes on the sheet:
GUARDING
16k9 - RN73C2B19K6ATG 5M - RG3216P-5004-B-T1 5k - PLT0805Z5001AST5 523 - TNPW0603523RBEEA 30k - ERA-6ARW303V 15k - ERA-3ARW153V 300 - RG1608N-301-W-T1 505k - RT0603BRD07505KL 100 - TNPU0805100RAZEN00 19K6 - RN73C2B19K6ATG
