# Repository mfkiwl/ETH1CDMM1ice40hx-stm32h7

## EAGLE design doc/pcb/2_digital_a.brd

Parts:
C1, C2, C3, C4, C6, C7, C8: 1u; R0805
C5, C9: 47u; SMC_C
C10, C11, C12, C13, C14: 100n; 0603
IC1: 4053D; SO16
IC2: LF33; DPAK
IC3: MSP430FR5994; QFP_05_80
JP1: PINHD-1X05_2.54; 1X05
JP2: PINHD-1X04_2.54; 1X04
LED1, LED2, LED3: LEDCHIPLED_0805; CHIPLED_0805
O1: OSC5032; OSC_5032
OK1, OK2: H11L1M; DIL06
R1, R3, R11, R15: 10k; R0805
R2, R6: 2k2; R0805
R4, R5: 22R; R0805
R7, R8, R9, R10, R12, R13, R14: 470; R0805
SV1: ML10
T1, T2: BC847; SOT23
U1: FT231XS; SSOP20_L
U2: MAX3232; SO016
U3: HC_05; BLUETOOTH_SMD
U$1: Si2333; SOT23-3
X1, X6: 22-23-2041
X2, X3: 22-23-2021
X4, X5: 22-23-2031

Connections:
+3V3: C3.1, C9.+, C11.1, C12.1, C13.1, C14.1, IC1.16 (VCC), IC2.3 (OUT), IC3.20 (DVCC2), IC3.40 (DVCC3), IC3.61 (DVCC1), IC3.80 (AVCC1), JP2.3, O1.1 (EN), O1.4 (VDD), OK1.6 (VCC), OK2.1 (A), R7.1, R11.2, R15.1, SV1.2, U2.16 (VCC), U$1.2 (S)
+10V: C5.+, IC2.1 (IN), X1.1, X2.2
BT_PWR: IC3.62 (P2.7), R11.1, U$1.1 (G)
E1: IC3.18 (P1.5), SV1.3
E2: IC3.17 (P1.4), SV1.4
E3: IC3.16 (P1.3), SV1.5
E4: IC3.15 (P8.0), SV1.6
E5: IC3.14 (P7.1), SV1.7
E6: IC3.13 (P7.0), SV1.8
E7: IC3.12 (P4.7), SV1.9
E8: IC3.11 (P6.3), SV1.10
GND: C3.2, C4.2, C5.-, C6.2, C7.2, C8.2, C9.-, C11.2, C12.2, C13.2, C14.2, IC1.6 (INH), IC1.7 (VEE), IC1.8 (GND), IC2.4 (VSS), IC3.19 (DVSS2), IC3.39 (DVSS3), IC3.60 (DVSS1), IC3.73 (AVSS3), IC3.76 (AVSS2), IC3.79 (AVSS1), JP1.4, JP1.5, JP2.4, O1.2 (GND), OK1.5 (GND), R1.1, R12.1, R13.1, R14.1, SV1.1, T1.2 (E), T2.2 (E), U1.6 (GND), U1.16 (GND), U2.15 (GND), U3.13 (GND), X1.4, X2.1, X3.1, X4.3
unnamed: IC3.38 (!RST/SBWTDIO), JP2.1, R15.2
unnamed: IC3.37 (TST/SBWTCK), JP2.2
unnamed: OK2.2 (C), R8.2
unnamed: R2.2, T1.1 (B)
unnamed: C10.1, OK1.1 (A), OK2.6 (VCC), R10.2, X6.2
unnamed: OK1.2 (C), R9.1
unnamed: OK2.4 (OUT), R10.1, X6.3
unnamed: C10.2, OK2.5 (GND), X6.4
unnamed: R9.2, X6.1
unnamed: LED2.C, R12.2
unnamed: IC3.44 (P8.1), LED2.A
unnamed: R6.2, T2.1 (B)
unnamed: T1.3 (C), X5.1
unnamed: T2.3 (C), X5.3
unnamed: X3.2, X5.2
unnamed: IC3.25 (P7.2), LED1.A
unnamed: IC3.26 (P7.3), LED3.A
unnamed: U3.12 (3V3), U$1.3 (D)
unnamed: LED3.C, R14.2
unnamed: LED1.C, R13.2
unnamed: IC3.74 (PJ.6/HFXIN), O1.3 (OUT)
unnamed: IC1.13 (X1), U1.20 (TXD)
unnamed: IC1.3 (Z1), U1.4 (RXD)
unnamed: C8.1, JP1.1, R3.2, U1.15 (VCC)
unnamed: R5.1, U1.11 (USBDP)
unnamed: JP1.2, R5.2
unnamed: JP1.3, R4.2
unnamed: R4.1, U1.12 (USBDM)
unnamed: C4.1, U1.3 (VCCIO), U1.13 (3V3OUT), U1.14 (!RESET)
unnamed: IC1.12 (X0), U2.9 (R2OUT)
unnamed: IC1.5 (Z0), U2.10 (T2IN)
unnamed: C7.1, U2.6 (V-)
unnamed: C6.1, U2.2 (V+)
unnamed: C2.2, U2.5 (C2-)
unnamed: C1.2, U2.1 (C1+)
unnamed: U2.8 (R2IN), X4.2
unnamed: C1.1, U2.3 (C1-)
unnamed: C2.1, U2.4 (C2+)
unnamed: U2.7 (T2OUT), X4.1
RE1: IC3.7 (P3.3), R2.1
RE2: IC3.6 (P3.2), R6.1
U0RXD: IC3.42 (P2.1), U3.1 (TX)
U0TXD: IC3.41 (P2.0), U3.2 (RX)
U1RXD: IC3.36 (P2.6), OK1.4 (OUT), R7.2
U1TXD: IC3.35 (P2.5), R8.1
U2RXD: IC1.14 (X), IC3.66 (P5.5)
U2TXD: IC1.4 (Z), IC3.65 (P5.4)
U3RXD: IC3.9 (P6.1), X1.3
U3TXD: IC3.8 (P6.0), X1.2
VBUS_DET: IC1.9 (C), IC1.10 (B), IC1.11 (A), IC3.67 (P5.6), R1.2, R3.1

Notes on the sheet:
USB connector header
RS232 connector header
Header for display board
Expansion, unused now
10V input from power supply
12V input from power supply
Relay out
UART link to ADC
HC05 BT module
MSP430FR5994

Board: 2 copper layers, 85.0 x 40.0 mm, 53 parts (0 on the bottom side), 62 nets.

## EAGLE design doc/pcb/2_input_v1.brd

Parts:
C1: 1n; C050-025X075
C2: 100n; C025-025X050
C3, C4: 4u7; E2,5-5
D1: 1N4148; SOD-80
IC1: DG419DJD; SO08
IC2: OPA140; SO08
IC3: 7805H; TO39
K1: HE3621
R1: 10M; R_TR193
R2: 100k; R_TR192
R3: 10k; R_TR191
X1: W237-2N
X2: 22-23-2041
X3: 22-23-2031
X4, X5: 22-23-2021

Connections:
+18V: C2.1, C3.+, IC1.4 (V+), IC2.7 (V+), IC3.1 (VI), X2.4
-18V: C2.2, IC1.7 (V-), IC2.4 (V-), X2.1
GND: C1.1, C3.-, C4.-, IC1.3 (GND), IC1.8 (S2), IC3.3 (GND), R1.P$1 (1), R3.P$2 (2), X1.2, X2.2, X2.3, X4.2, X5.2
unnamed: K1.4, R1.P$2 (2)
unnamed: K1.1 (S), R2.P$1 (1), X1.1
unnamed: C1.2, IC1.2 (S1), R2.P$2 (2)
unnamed: IC1.1 (D), IC2.3 (+IN)
unnamed: D1.K, K1.2 (+), X3.2
unnamed: IC2.2 (-IN), IC2.6 (OUT), X5.1
unnamed: C4.+, IC1.5 (VL), IC3.2 (VO)
unnamed: D1.A, K1.3 (-), X3.3
unnamed: IC1.6 (IN), R3.P$1 (1), X4.1

Notes on the sheet:
OUTPUT
AZ switch signal
INPUT
Power
Relay signal
Here, +-18V net has actually +-22V

Board: 2 copper layers, 85.0 x 40.0 mm, 17 parts (0 on the bottom side), 12 nets.

## EAGLE design doc/pcb/2_disp.brd

Parts:
C1, C2, C3, C6, C7: M1; R0805
C4, C5: 22p; R0805
C8, C17, C18: 47u; SMC_C
C9, C11, C14, C16: 1u; R0805
C10, C12: 4n7; R0805
C13: 33p; R0805
C15: 100n; R0805
D1: B340; SMB
DI1: LQ3XX; LQ_DISP
DI2, DI3, DI4, DI5, DI6, DI7, DI8: LQ4XX; LQ_DISP
IC1, IC3, IC4, IC6: STP16CPS05; QSOP24
IC2: MC9S08PT60TQ32; TQFP32-8
IC5: MCP1703; SOT89
IC7: TPS54331; SO-08
JP1: PINHD-1X04_2.54; 1X04
K1, K2, K3, K4, K5: SWITCH_MINI6450; SWITCH_6450
L1: SRP7030; BOURNS_SRP7030
LED1: LEDCHIPLED_0805; CHIPLED_0805
LED2, LED3: LEDCHIPLED_1206; CHIPLED_1206
Q1: 5MHz; TC38H
R1, R2, R3: 470; R0805
R4, R5, R6, R10, R16, R18, R20: 1k5; R0805
R7: 47; R0805
R8, R19: 0; R0805
R9: DNP; R0805
R11, R12, R13, R14, R15: 10k; R0805
R17: 27k; R0805
R21, R22: 1k; R0805
X1: 22-23-2041

Connections:
+5V: C1.2, C2.2, C3.2, C6.2, C7.2, C14.2, IC1.24 (VDD), IC2.3 (VDD), IC2.4 (VDDA), IC3.24 (VDD), IC4.24 (VDD), IC5.3 (OUT), IC6.24 (VDD), JP1.2, R11.1, R12.1, R13.1, R14.1, R15.1
+10V: C8.+, C9.2, C11.2, IC5.2 (IN), IC5.2@1 (IN), IC7.2 (IN), X1.1
D_CK: IC1.3 (SCK), IC2.10 (B4/MISO0), IC3.3 (SCK), IC4.3 (SCK), IC6.3 (SCK)
D_DI: IC1.2 (SDI), IC2.9 (B5/SS0)
D_EN: IC7.3 (EN), R7.1
D_LE: IC1.4 (LE), IC2.11 (C3/AD11), IC3.4 (LE), IC4.4 (LE), IC6.4 (LE)
D_OE: IC1.21 (!OE), IC2.12 (C2/AD10), IC3.21 (!OE), IC4.21 (!OE), IC6.21 (!OE)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.-, C9.1, C10.1, C11.1, C13.1, C14.1, C16.1, C17.-, C18.-, D1.A, IC1.1 (GND), IC2.5 (VSSA), IC2.6 (VSS), IC3.1 (GND), IC4.1 (GND), IC5.1 (VSS), IC6.1 (GND), IC7.7 (GND), JP1.1, K1.P$1, K2.P$1, K3.P$1, K4.P$1, K5.P$1, R1.2, R2.2, R3.2, R6.1, R10.1, R16.1, R17.1, R18.1, R19.2, R22.1, X1.4
GNDA: R19.1
K1: IC2.13 (C1/AD9), K1.P$2, R11.2
K2: IC2.14 (C0/AD8), K2.P$2, R12.2
K3: IC2.15 (B3/MOSI0/AD7), K3.P$2, R13.2
K4: IC2.16 (B2/SCK0/AD6), K4.P$2, R14.2
K5: IC2.17 (B1/TXD0/AD5), K5.P$2, R15.2
unnamed: DI1.11 (A), IC1.5 (O1)
unnamed: DI1.10 (B), IC1.6 (O2)
unnamed: DI1.8 (M), IC1.7 (O3)
unnamed: DI1.7, IC1.8 (O4)
unnamed: DI2.1 (A), IC1.13 (O9)
unnamed: DI2.13 (B), IC1.14 (O10)
unnamed: DI2.10 (C), IC1.15 (O11)
unnamed: DI2.8 (D), IC1.16 (O12)
unnamed: DI2.7 (E), IC1.17 (O13)
unnamed: DI2.2 (F), IC1.18 (O14)
unnamed: DI2.11 (G), IC1.19 (O15)
unnamed: DI2.6 (H), IC1.20 (O16)
unnamed: DI3.1 (A), IC3.5 (O1)
unnamed: DI3.13 (B), IC3.6 (O2)
unnamed: DI3.10 (C), IC3.7 (O3)
unnamed: DI3.8 (D), IC3.8 (O4)
unnamed: IC3.23 (REXT), R10.2
unnamed: DI3.7 (E), IC3.9 (O5)
unnamed: DI3.2 (F), IC3.10 (O6)
unnamed: DI3.11 (G), IC3.11 (O7)
unnamed: DI3.6 (H), IC3.12 (O8)
unnamed: DI4.1 (A), IC3.13 (O9)
unnamed: DI4.13 (B), IC3.14 (O10)
unnamed: DI4.10 (C), IC3.15 (O11)
unnamed: DI4.8 (D), IC3.16 (O12)
unnamed: DI4.7 (E), IC3.17 (O13)
unnamed: DI4.2 (F), IC3.18 (O14)
unnamed: DI4.11 (G), IC3.19 (O15)
unnamed: DI4.6 (H), IC3.20 (O16)
unnamed: DI5.1 (A), IC4.5 (O1)
unnamed: DI5.13 (B), IC4.6 (O2)
unnamed: DI5.10 (C), IC4.7 (O3)
unnamed: DI5.8 (D), IC4.8 (O4)
unnamed: IC4.23 (REXT), R16.2
unnamed: DI5.7 (E), IC4.9 (O5)
unnamed: IC1.23 (REXT), R6.2
unnamed: DI5.2 (F), IC4.10 (O6)
unnamed: DI5.11 (G), IC4.11 (O7)
unnamed: DI5.6 (H), IC4.12 (O8)
unnamed: DI6.1 (A), IC4.13 (O9)
unnamed: DI6.13 (B), IC4.14 (O10)
unnamed: DI6.10 (C), IC4.15 (O11)
unnamed: DI6.8 (D), IC4.16 (O12)
unnamed: DI6.7 (E), IC4.17 (O13)
unnamed: DI6.2 (F), IC4.18 (O14)
unnamed: DI6.11 (G), IC4.19 (O15)
unnamed: DI6.6 (H), IC4.20 (O16)
unnamed: DI7.1 (A), IC6.5 (O1)
unnamed: DI7.13 (B), IC6.6 (O2)
unnamed: DI7.10 (C), IC6.7 (O3)
unnamed: DI7.8 (D), IC6.8 (O4)
unnamed: IC6.23 (REXT), R18.2
unnamed: DI7.7 (E), IC6.9 (O5)
unnamed: DI7.2 (F), IC6.10 (O6)
unnamed: DI7.11 (G), IC6.11 (O7)
unnamed: DI7.6 (H), IC6.12 (O8)
unnamed: DI8.1 (A), IC6.13 (O9)
unnamed: DI8.13 (B), IC6.14 (O10)
unnamed: DI8.10 (C), IC6.15 (O11)
unnamed: DI8.8 (D), IC6.16 (O12)
unnamed: DI8.7 (E), IC6.17 (O13)
unnamed: DI8.2 (F), IC6.18 (O14)
unnamed: DI8.11 (G), IC6.19 (O15)
unnamed: DI8.6 (H), IC6.20 (O16)
unnamed: IC2.8 (B6/SDA/XTAL), R8.2
unnamed: C5.2, Q1.1, R8.1, R9.1
unnamed: C4.2, IC2.7 (B7/SCL/EXTAL), Q1.2, R9.2
unnamed: IC2.18 (B0/RXD0/AD4), R7.2
unnamed: IC1.22 (SDO), IC3.2 (SDI)
unnamed: IC3.22 (SDO), IC4.2 (SDI)
unnamed: IC4.22 (SDO), IC6.2 (SDI)
unnamed: LED2.C, R2.1
unnamed: IC2.23 (A3/TXD0/SCL), R5.1
unnamed: IC2.24 (A2/RXD0/SDA), R4.1
unnamed: R5.2, X1.3
unnamed: R4.2, X1.2
unnamed: IC2.32 (A4/BKGD), JP1.4
unnamed: IC2.31 (A5/IRQ/RST), JP1.3
unnamed: IC2.21 (D3/SS1), LED2.A
unnamed: LED1.C, R1.1
unnamed: C15.2, D1.C, IC7.8 (PH), L1.P$1
unnamed: C15.1, IC7.1 (BOOT)
unnamed: IC2.25 (A1), LED1.A
unnamed: IC7.5 (SEN), R21.1, R22.2
unnamed: R20.1, R21.2
unnamed: C12.1, R17.2
unnamed: C12.2, C13.2, IC7.6 (COMP)
unnamed: C10.2, IC7.4 (SS)
unnamed: LED3.C, R3.1
unnamed: IC2.22 (D2MISO1), LED3.A
V+: C16.2, C17.+, C18.+, DI1.1 (CA1), DI1.3 (CA2), DI1.14 (CA3), DI2.3 (CA1), DI2.9 (CA2), DI2.14 (CA3), DI3.3 (CA1), DI3.9 (CA2), DI3.14 (CA3), DI4.3 (CA1), DI4.9 (CA2), DI4.14 (CA3), DI5.3 (CA1), DI5.9 (CA2), DI5.14 (CA3), DI6.3 (CA1), DI6.9 (CA2), DI6.14 (CA3), DI7.3 (CA1), DI7.9 (CA2), DI7.14 (CA3), DI8.3 (CA1), DI8.9 (CA2), DI8.14 (CA3), L1.P$2, R20.2

Notes on the sheet:
drivers - STP16DPS05 LED - LQ370 and LQ470
MC9S08PA16A
ISP header
to digital board
6,8u
populate to connect GND and spacer to front panel

Board: 2 copper layers, 110.0 x 43.0 mm, 68 parts (51 on the bottom side), 104 nets.

## EAGLE design doc/pcb/2_pow_input.brd

Parts:
F1: 63mA; SH22,5A
R1: S05K300
X1, X2, X3: W237-02P; W237-132

Connections:
unnamed: F1.2, X1.2
unnamed: R1.1, X2.1, X3.2
unnamed: F1.1, R1.2, X3.1
unnamed: X1.1, X2.2

Notes on the sheet:
230V input
Switch
output to transformer

Board: 2 copper layers, 70.0 x 18.0 mm, 5 parts (0 on the bottom side), 4 nets.

## EAGLE design doc/pcb/2_adc.brd

Parts:
C1, C6: 1u; R0805
C2, C3, C4, C5, C23: 47u; SMC_C
C7: 100n; C050-035X075
C8: 2n2; C150-054X183
C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C24: 100n; R0805
D1: 1N4148; SOD-80
IC1: 7805T; TO220H
IC2: 7905; TO220H
IC3: TL7712; SO08
IC4: LM399H; TO39/4
IC5: DG211CJD; SO16
IC6: DG419DJD; SO08
IC7: OPA140; SO08
IC8: TL071D; SO08
IC9: AD8676; SO08
IC10: LT1116; SO-08
IC11: EPM240T100C5N; QFP50P1600X1600X120-100N
JP1: PINHD-1X06_2.54; 1X06
LED1, LED2, LED3: LEDCHIPLED_0805; CHIPLED_0805
QG1: SG-615PCG; SG-615
R1, R2, R3: 10k; R0805
R4: 0; R_TR191
R5: 6k95; R_TR191
R6: 1k96; R_TR191
R7: 3k01; R_TR191
R8, R9, R10, R11, R12, R13: R_0805; R0805
R14, R15, R16: 470; R0805
R17: 0; R0805
SV1, SV2: ML10
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TPB1,27; B1,27
U$1: LT5400-100k-100k; MSOP8-EP
U$2: LT5400-5k-1k; MSOP8-EP
U$3: LT5400-10k+10k; MSOP8-EP
X1, X5: 22-23-2061
X2, X3: 22-23-2021
X4: 22-23-2041

Connections:
+3V3: C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.+, C24.2, IC11.9 (VCCIO1_2), IC11.13 (VCCINT_2), IC11.31 (VCCIO1), IC11.45 (VCCIO1_3), IC11.59 (VCCIO2_2), IC11.63 (VCCINT), IC11.80 (VCCIO2_3), IC11.94 (VCCIO2), QG1.4 (VCC), SV1.9, SV2.4, X1.2, X4.3, X5.5
+5V: C4.+, C12.2, IC1.3 (VO), IC5.12 (VL), IC6.5 (VL), IC10.1 (VCC+)
+12V: C2.+, C9.2, C10.2, C11.2, C14.2, C15.2, IC1.1 (VI), IC3.7 (SENSE), IC3.8 (+VS), IC4.3, IC5.13 (V+), IC6.4 (V+), IC7.7 (V+), IC8.7 (V+), IC9.8 (V+), R1.2, X1.3
-5V: C5.-, C13.2, IC2.3 (VO), IC10.4 (VCC-)
-12V: C3.-, C10.1, C11.1, C14.1, C15.1, IC2.2 (VI), IC5.4 (V-), IC6.7 (V-), IC7.4 (V-), IC9.4 (V-), X1.6
ADC_IN: U$1.1 (R1A), X2.2
COMP: IC10.7 (Q), R13.2
DGND: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.-, C24.1, IC11.10 (GNDIO_6), IC11.11 (GNDINT), IC11.32 (GNDIO_3), IC11.46 (GNDIO_2), IC11.60 (GNDIO_4), IC11.65 (GNDINT_2), IC11.79 (GNDIO), IC11.93 (GNDIO_5), QG1.2 (GND), R14.2, R15.2, R16.2, R17.2, SV1.10, SV2.2, SV2.10, X1.1, X4.4, X5.6
GND: C1.1, C2.-, C3.+, C4.-, C5.+, C6.1, C7.2, C9.1, C12.1, C13.1, IC1.2 (GND), IC2.1 (GND), IC3.4 (GND), IC4.2, IC4.4, IC5.5 (GND), IC6.3 (GND), IC7.3 (+IN), IC8.4 (V-), IC9.5 (+IN), IC10.3 (IN-), IC10.5 (LE), IC10.6 (GND), R2.1, R5.P$1 (1), R17.1, U$1.EP (SH), U$2.6 (R3B), U$2.EP (SH), U$3.EP (SH), X1.4, X1.5, X2.1, X3.1
unnamed: IC8.2 (-IN), R5.P$2 (2), R7.P$2 (2)
unnamed: IC8.6 (OUT), R6.P$1 (1), R7.P$1 (1)
unnamed: IC5.2 (D), U$1.7 (R2B)
unnamed: C8.2, IC5.15 (D), IC7.6 (OUT), IC10.2 (IN+)
unnamed: IC11.53 (IO_38), R9.1
unnamed: C8.1, IC5.3 (S), IC5.7 (D), IC5.10 (D), IC5.14 (S), IC7.2 (-IN)
unnamed: U$2.1 (R1A), U$2.4 (R4A)
unnamed: IC11.35 (IO_11), LED2.A
unnamed: IC11.24 (TCK), SV2.1
unnamed: IC11.25 (TDO), SV2.3
unnamed: IC6.1 (D), IC9.3 (+IN)
unnamed: IC11.22 (TMS), SV2.5
unnamed: IC11.23 (TDI), SV2.9
unnamed: IC11.14 (IO/GCLK1), QG1.3 (FO)
unnamed: IC5.11 (S), U$1.6 (R3B)
unnamed: C6.2, IC3.1 (REF)
unnamed: IC11.1 (IO_12), SV1.1
unnamed: IC11.2 (IO_15), SV1.2
unnamed: IC5.6 (S), U$1.5 (R4B)
unnamed: IC11.54 (IO_39), R10.1
unnamed: IC11.55 (IO_40), R11.1
unnamed: IC11.56 (IO_41), R12.1
unnamed: IC11.51 (IO_36), R8.1
unnamed: IC6.2 (S1), U$2.7 (R2B), U$2.8 (R1B)
unnamed: IC11.58 (IO_45), R13.1
unnamed: IC11.21 (IO_8), X5.4
unnamed: IC11.20 (IO_7), X5.3
unnamed: IC11.19 (IO_6), X5.2
unnamed: IC11.18 (IO_5), X5.1
unnamed: IC11.34 (IO_10), LED3.A
unnamed: IC11.33 (IO_9), LED1.A
unnamed: C1.2, IC3.3 (CT)
unnamed: LED2.C, R14.1
unnamed: LED3.C, R15.1
unnamed: LED1.C, R16.1
unnamed: IC11.49 (IO_30), TP1.TP
unnamed: IC11.50 (IO_32), TP2.TP
unnamed: IC11.48 (IO_28), TP3.TP
unnamed: IC11.36 (IO_14), TP4.TP
unnamed: IC11.37 (IO_18), TP5.TP
unnamed: IC11.38 (IO_22), TP6.TP
unnamed: JP1.1, TP7.TP
unnamed: JP1.2, TP8.TP
unnamed: JP1.3, TP9.TP
unnamed: JP1.4, TP10.TP
unnamed: JP1.5, TP11.TP
unnamed: JP1.6, TP12.TP
unnamed: IC11.3 (IO_19), SV1.3
unnamed: C7.1, IC6.8 (S2), R4.P$1 (1), U$2.5 (R4B)
unnamed: IC4.1, IC8.3 (+IN), R3.1, R4.P$2 (2), R6.P$2 (2)
unnamed: IC11.4 (IO_23), SV1.4
unnamed: IC11.5 (IO_25), SV1.5
unnamed: IC11.6 (IO_29), SV1.6
unnamed: IC11.7 (IO_33), SV1.7
unnamed: IC11.8 (IO_35), SV1.8
unnamed: IC11.12 (IO/GCLK0), X4.1
unnamed: IC11.15 (IO_2), X4.2
unnamed: D1.A, IC3.6 (RESET), R2.2
unnamed: D1.K, R3.2
unnamed: U$1.2 (R2A), U$1.8 (R1B)
unnamed: IC9.6 (-IN), U$3.5 (R4B), U$3.6 (R3B), U$3.7 (R2B), U$3.8 (R1B)
unnamed: U$2.2 (R2A), U$2.3 (R3A)
unnamed: IC3.2 (!RESIN), R1.1, X3.2
SW_ID: IC5.16 (IN), R11.2
SW_IIN: IC5.1 (IN), R10.2
SW_IR+: IC5.8 (IN), R9.2
SW_IR-: IC5.9 (IN), R12.2
SW_VRH: IC6.6 (IN), R8.2
VREF+: IC9.1 (OUT), IC9.2 (-IN), U$1.4 (R4A), U$3.3 (R3A), U$3.4 (R4A)
VREF-: IC9.7 (OUT), U$1.3 (R3A), U$3.1 (R1A), U$3.2 (R2A)

Notes on the sheet:
LT5400-5k-1k
LT5400-10k-10k
LT5400-100k-100k
LT1116

Board: 2 copper layers, 95.0 x 85.0 mm, 80 parts (0 on the bottom side), 79 nets.

## EAGLE design doc/pcb/2_power_a.brd

Parts:
B1, B3, B4, B5, B6, B7: RB1A
B2: FBU4
C1, C5, C8, C11, C14, C17: CPOL-EUE5-10.5; E5-10,5
C2, C6, C9, C12, C15, C18: 22u; E2,5-6
C3, C7, C10, C13, C16, C19: CPOL-EUE3.5-8; E3,5-8
C4: 2m2; E5-13
D1, D2, D3, D4, D5, D6: 1N4007; DO41
IC1, IC2, IC3, IC4, IC5, IC6: LM317TS; 317TS
LED2, LED3, LED4, LED5, LED6, LED7: LED3MM
R1, R3, R5, R7, R9, R11: 240; R_TR191
R2, R4, R6, R8, R10, R12: R-TRIMM64Y; RTRIM64Y
R14, R15, R16, R17, R18, R19: R191S; R_R191S
U$1, U$2, U$3, U$4, U$5, U$6, U$7, U$8, U$9, U$10, U$11, U$12, U$13, U$14: TERM_2P_SBP; TERM-2P_381_BP

Connections:
unnamed: B1.AC1, U$2.P$1
unnamed: B1.AC2, U$2.P$2
unnamed: B1.+, C1.+, D1.K, IC1.3 (IN)
unnamed: B1.-, C1.-, C2.-, C3.-, LED2.K (C), R2.1 (E), R2.2 (S), U$4.P$1
unnamed: C3.+, D1.A, IC1.2 (OUT), R1.P$2 (2), R14.P$2 (2), U$4.P$2
unnamed: C2.+, IC1.1 (ADJ), R1.P$1 (1), R2.3 (A)
unnamed: B2.AC1, U$1.P$1
unnamed: B2.AC2, U$1.P$2
unnamed: B2.-, C4.-, U$3.P$1
unnamed: B2.+, C4.+, U$3.P$2
unnamed: LED2.A, R14.P$1 (1)
unnamed: B3.AC1, U$5.P$1
unnamed: B3.AC2, U$5.P$2
unnamed: B3.+, C5.+, D2.K, IC2.3 (IN)
unnamed: B3.-, C5.-, C6.-, C7.-, LED3.K (C), R4.1 (E), R4.2 (S), U$6.P$1
unnamed: C7.+, D2.A, IC2.2 (OUT), R3.P$2 (2), R15.P$2 (2), U$6.P$2
unnamed: C6.+, IC2.1 (ADJ), R3.P$1 (1), R4.3 (A)
unnamed: B4.AC1, U$7.P$1
unnamed: B4.AC2, U$7.P$2
unnamed: B4.+, C8.+, D3.K, IC3.3 (IN)
unnamed: B4.-, C8.-, C9.-, C10.-, LED4.K (C), R6.1 (E), R6.2 (S), U$8.P$1
unnamed: C10.+, D3.A, IC3.2 (OUT), R5.P$2 (2), R16.P$2 (2), U$8.P$2
unnamed: C9.+, IC3.1 (ADJ), R5.P$1 (1), R6.3 (A)
unnamed: B5.AC1, U$9.P$1
unnamed: B5.AC2, U$9.P$2
unnamed: B5.+, C11.+, D4.K, IC4.3 (IN)
unnamed: B5.-, C11.-, C12.-, C13.-, LED5.K (C), R8.1 (E), R8.2 (S), U$10.P$1
unnamed: C13.+, D4.A, IC4.2 (OUT), R7.P$2 (2), R17.P$2 (2), U$10.P$2
unnamed: C12.+, IC4.1 (ADJ), R7.P$1 (1), R8.3 (A)
unnamed: B6.AC1, U$11.P$1
unnamed: B6.AC2, U$11.P$2
unnamed: B6.+, C14.+, D5.K, IC5.3 (IN)
unnamed: B6.-, C14.-, C15.-, C16.-, LED6.K (C), R10.1 (E), R10.2 (S), U$12.P$1
unnamed: C16.+, D5.A, IC5.2 (OUT), R9.P$2 (2), R18.P$2 (2), U$12.P$2
unnamed: C15.+, IC5.1 (ADJ), R9.P$1 (1), R10.3 (A)
unnamed: B7.AC1, U$13.P$1
unnamed: B7.AC2, U$13.P$2
unnamed: B7.+, C17.+, D6.K, IC6.3 (IN)
unnamed: B7.-, C17.-, C18.-, C19.-, LED7.K (C), R12.1 (E), R12.2 (S), U$14.P$1
unnamed: C19.+, D6.A, IC6.2 (OUT), R11.P$2 (2), R19.P$2 (2), U$14.P$2
unnamed: C18.+, IC6.1 (ADJ), R11.P$1 (1), R12.3 (A)
unnamed: LED3.A, R15.P$1 (1)
unnamed: LED4.A, R16.P$1 (1)
unnamed: LED5.A, R17.P$1 (1)
unnamed: LED6.A, R18.P$1 (1)
unnamed: LED7.A, R19.P$1 (1)

Notes on the sheet:
3,3V for ADC
12V for relay
15V for ADC
22V for input
10V for digi board

Notices in the files:
parts and their libraries:
SparkFun-DigitalIC: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
