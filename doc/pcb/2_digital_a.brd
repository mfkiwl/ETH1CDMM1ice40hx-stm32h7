# Repository mfkiwl/ETH1CDMM1ice40hx-stm32h7 (continued)

## EAGLE design doc/pcb/2_power_a.brd (continued)

Board: 2 copper layers, 95.0 x 70.0 mm, 76 parts (0 on the bottom side), 46 nets.

## Commit log

2020-02-03 Schematic design
2020-02-04 Schematic design, added new 3d models.
2020-02-05 DC_Amplifier.sch design.
2020-02-09 Schematic and software design.
2020-02-09 No unconnected nets in schematic
2020-02-12 Footprint assigment
2020-02-13 Footprint assignment done.
2020-02-14 FPGA was wrong, fixed. PCB design.
2020-02-18 Bug fix in schematic, PCB layout.
2020-02-20 PCB layout
2020-03-03 Schematic and PCB changes
2020-03-05 Added EMC shield.
2020-03-05 Redesigned the PCB for the EMC shield. Moved power and ground planes.
2020-03-06 PCB layout.
2020-03-06 PCB layout done.
2020-03-08 PCB and BOM list done.
2020-03-10 Fix small bugs in PCB.
2020-03-10 Gerber files created
2020-03-10 PCB done
2020-03-12 Changes in FPGA part.
2020-03-12 PCB solder mask changes
2020-03-12 Changed TO-71 footprint
2020-03-16 PCB changes
2020-03-17 Gerber send.
2020-07-19 FreeRTOS works, LwIP works, SDRAM works.
2020-08-12 FPGA code development
2020-08-20 Running SPI example between FGPA and MCU
2020-09-06 SCPI commands define.
2020-09-22 ADC shows signs of life.
2020-09-28 Software development.
2020-09-29 Rebuiled the main control structure.
2020-09-30 EEPROM function works now. Using ee24 lib from https://github.com/nimaltd/ee24
2020-10-01 Fixed bugs in schematic and PCB. Software development.
2020-10-02 Software development
2020-10-04 Part of the switching path works. Fixed problem with ADC circuit (bad solder).
